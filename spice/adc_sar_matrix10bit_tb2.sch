v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
F {}
E {}
L 4 6640 -2360 6640 -2320 {}
L 4 6620 -2360 6660 -2360 {}
L 4 6560 -2360 6560 -2320 {}
L 4 6540 -2360 6580 -2360 {}
L 4 6480 -2360 6480 -2320 {}
L 4 6460 -2360 6500 -2360 {}
L 4 6400 -2360 6400 -2320 {}
L 4 6380 -2360 6420 -2360 {}
L 4 6320 -2360 6320 -2320 {}
L 4 6300 -2360 6340 -2360 {}
L 4 6780 -2360 6780 -2320 {}
L 4 6760 -2360 6800 -2360 {}
L 4 6280 -2320 6840 -2320 {}
L 4 6675 -2365 6685 -2365 {}
L 4 6695 -2365 6705 -2365 {}
L 4 6715 -2365 6725 -2365 {}
L 4 6735 -2365 6745 -2365 {}
L 4 6300 -2370 6340 -2370 {}
L 4 6380 -2370 6420 -2370 {}
L 4 6460 -2370 6500 -2370 {}
L 4 6540 -2370 6580 -2370 {}
L 4 6620 -2370 6660 -2370 {}
L 4 6760 -2370 6800 -2370 {}
L 4 6640 -2410 6640 -2370 {}
L 4 6560 -2410 6560 -2370 {}
L 4 6480 -2410 6480 -2370 {}
L 4 6400 -2410 6400 -2370 {}
L 4 6320 -2410 6320 -2370 {}
L 4 6780 -2410 6780 -2370 {}
L 4 6640 -2230 6640 -2190 {}
L 4 6620 -2230 6660 -2230 {}
L 4 6560 -2230 6560 -2190 {}
L 4 6540 -2230 6580 -2230 {}
L 4 6480 -2230 6480 -2190 {}
L 4 6460 -2230 6500 -2230 {}
L 4 6400 -2230 6400 -2190 {}
L 4 6380 -2230 6420 -2230 {}
L 4 6320 -2230 6320 -2190 {}
L 4 6300 -2230 6340 -2230 {}
L 4 6780 -2230 6780 -2190 {}
L 4 6760 -2230 6800 -2230 {}
L 4 6280 -2280 6840 -2280 {}
L 4 6675 -2235 6685 -2235 {}
L 4 6695 -2235 6705 -2235 {}
L 4 6715 -2235 6725 -2235 {}
L 4 6735 -2235 6745 -2235 {}
L 4 6300 -2240 6340 -2240 {}
L 4 6380 -2240 6420 -2240 {}
L 4 6460 -2240 6500 -2240 {}
L 4 6540 -2240 6580 -2240 {}
L 4 6620 -2240 6660 -2240 {}
L 4 6760 -2240 6800 -2240 {}
L 4 6640 -2280 6640 -2240 {}
L 4 6560 -2280 6560 -2240 {}
L 4 6480 -2280 6480 -2240 {}
L 4 6400 -2280 6400 -2240 {}
L 4 6320 -2280 6320 -2240 {}
L 4 6780 -2280 6780 -2240 {}
L 4 6240 -2280 6280 -2280 {}
L 4 6240 -2320 6280 -2320 {}
L 4 6210 -2320 6240 -2330 {}
L 4 6210 -2280 6240 -2270 {}
L 4 6180 -2280 6210 -2280 {}
L 4 6180 -2320 6210 -2320 {}
L 4 6140 -2320 6180 -2320 {}
L 4 6140 -2280 6180 -2280 {}
L 4 6880 -2340 6880 -2260 {}
L 4 6880 -2260 6960 -2300 {}
L 4 6880 -2340 6960 -2300 {}
L 4 6840 -2320 6880 -2320 {}
L 4 6840 -2280 6880 -2280 {}
L 4 6310 -2420 6320 -2410 {}
L 4 6320 -2460 6320 -2430 {}
L 4 6390 -2420 6400 -2410 {}
L 4 6390 -2440 6390 -2430 {}
L 4 6400 -2460 6400 -2430 {}
L 4 6410 -2480 6410 -2430 {}
L 4 6470 -2420 6480 -2410 {}
L 4 6470 -2440 6470 -2430 {}
L 4 6480 -2460 6480 -2430 {}
L 4 6490 -2480 6490 -2430 {}
L 4 6550 -2420 6560 -2410 {}
L 4 6550 -2440 6550 -2430 {}
L 4 6560 -2460 6560 -2430 {}
L 4 6570 -2480 6570 -2430 {}
L 4 6630 -2420 6640 -2410 {}
L 4 6630 -2440 6630 -2430 {}
L 4 6640 -2460 6640 -2430 {}
L 4 6650 -2480 6650 -2430 {}
L 4 6770 -2420 6780 -2410 {}
L 4 6770 -2440 6770 -2430 {}
L 4 6780 -2460 6780 -2430 {}
L 4 6790 -2480 6790 -2430 {}
L 4 6280 -2440 6770 -2440 {}
L 4 6280 -2460 6780 -2460 {}
L 4 6280 -2480 6790 -2480 {}
L 4 6310 -2180 6320 -2190 {}
L 4 6320 -2170 6320 -2140 {}
L 4 6390 -2180 6400 -2190 {}
L 4 6390 -2170 6390 -2160 {}
L 4 6400 -2170 6400 -2140 {}
L 4 6410 -2170 6410 -2120 {}
L 4 6470 -2180 6480 -2190 {}
L 4 6470 -2170 6470 -2160 {}
L 4 6480 -2170 6480 -2140 {}
L 4 6490 -2170 6490 -2120 {}
L 4 6550 -2180 6560 -2190 {}
L 4 6550 -2170 6550 -2160 {}
L 4 6560 -2170 6560 -2140 {}
L 4 6570 -2170 6570 -2120 {}
L 4 6630 -2180 6640 -2190 {}
L 4 6630 -2170 6630 -2160 {}
L 4 6640 -2170 6640 -2140 {}
L 4 6650 -2170 6650 -2120 {}
L 4 6770 -2180 6780 -2190 {}
L 4 6770 -2170 6770 -2160 {}
L 4 6780 -2170 6780 -2140 {}
L 4 6790 -2170 6790 -2120 {}
L 4 6280 -2160 6770 -2160 {}
L 4 6280 -2140 6780 -2140 {}
L 4 6280 -2120 6790 -2120 {}
L 4 6960 -2300 7030 -2300 {}
L 4 6310 -2480 6310 -2430 {}
L 4 6310 -2170 6310 -2160 {}
T {Tie C0 to VDD - Enable C0 at P-input
Tie C0 to VSS - Disable C0 at N-input} 2460 -2740 0 0 0.3 0.3 {}
T {127 Wafflecaps (13x10-1) for 7 Bit. 
3 Bin-Caps (4/8F, 2/8F and 1/8F) for 3 extra Bit.
+1 Unitcap.
--> 1023 unitcaps + 1 unitcap = 1024 unitcaps for 10 Bit
1024*0.45fF=0.4608pF} 5100 -2340 0 0 0.6 0.6 {}
T {INP} 6070 -2350 0 0 0.6 0.6 {}
T {INN} 6070 -2300 0 0 0.6 0.6 {}
T {+} 6880 -2340 0 0 0.6 0.6 {}
T {-} 6880 -2300 0 0 0.6 0.6 {}
T {C0} 6320 -2360 0 0 0.6 0.6 {}
T {C} 6400 -2360 0 0 0.6 0.6 {}
T {2C} 6480 -2360 0 0 0.6 0.6 {}
T {4C} 6560 -2360 0 0 0.6 0.6 {}
T {8C} 6640 -2360 0 0 0.6 0.6 {}
T {512C} 6780 -2360 0 0 0.6 0.6 {}
T {VDD} 6230 -2500 0 0 0.4 0.4 {}
T {vcm} 6230 -2480 0 0 0.4 0.4 {}
T {VSS} 6230 -2460 0 0 0.4 0.4 {}
T {VDD} 6230 -2100 2 1 0.4 0.4 {}
T {vcm} 6230 -2120 2 1 0.4 0.4 {}
T {VSS} 6230 -2140 2 1 0.4 0.4 {}
T {C0} 6320 -2280 0 0 0.6 0.6 {}
T {C} 6400 -2280 0 0 0.6 0.6 {}
T {2C} 6480 -2280 0 0 0.6 0.6 {}
T {4C} 6560 -2280 0 0 0.6 0.6 {}
T {8C} 6640 -2280 0 0 0.6 0.6 {}
T {1C+1023C thermometer-coded} 6350 -2520 0 0 0.4 0.4 {}
T {512C} 6780 -2280 0 0 0.6 0.6 {}
T {extra} 6330 -2390 0 0 0.2 0.2 {}
T {bin1} 6410 -2390 0 0 0.2 0.2 {}
T {bin2} 6490 -2390 0 0 0.2 0.2 {}
T {bin4} 6570 -2390 0 0 0.2 0.2 {}
T {waffle8} 6790 -2390 0 0 0.2 0.2 {}
T {waffle8} 6650 -2390 0 0 0.2 0.2 {}
T {extra} 6330 -2220 0 0 0.2 0.2 {}
T {bin1} 6410 -2220 0 0 0.2 0.2 {}
T {bin2} 6490 -2220 0 0 0.2 0.2 {}
T {bin4} 6570 -2220 0 0 0.2 0.2 {}
T {waffle8} 6790 -2220 0 0 0.2 0.2 {}
T {waffle8} 6650 -2220 0 0 0.2 0.2 {}
T {Tie C0 to VDD - Enable C0 at P-input
Tie C0 to VSS - Disable C0 at N-input} 1410 -3100 0 0 0.3 0.3 {}
N 3980 -1830 3980 -1810 {lab=GND}
N 3980 -1970 3980 -1950 {lab=VDD}
N 3870 -1890 3920 -1890 {lab=clk}
N 4040 -1890 4120 -1890 {lab=#net25}
N 4190 -1830 4190 -1800 {lab=GND}
N 3870 -1830 3870 -1810 {lab=GND}
N 3630 -1850 3630 -1830 {
lab=VDD}
N 3630 -1770 3630 -1750 {
lab=GND}
N 3380 -1830 3380 -1740 {lab=#net26}
N 3890 -1290 3890 -1270 {lab=GND}
N 3100 -1880 3100 -1830 {lab=sw}
N 3100 -1770 3100 -1750 {lab=GND}
N 3100 -1570 3100 -1540 {lab=sw_n}
N 3100 -1480 3100 -1460 {lab=GND}
N 2380 -2000 2380 -1960 {lab=row_n[0]}
N 2380 -1900 2380 -1870 {lab=GND}
N 2380 -1790 2380 -1750 {lab=row_n[1]}
N 2380 -1690 2380 -1660 {lab=GND}
N 2380 -1580 2380 -1540 {lab=row_n[2]}
N 2380 -1480 2380 -1450 {lab=GND}
N 2380 -1360 2380 -1320 {lab=row_n[3]}
N 2380 -1260 2380 -1230 {lab=GND}
N 2380 -1150 2380 -1110 {lab=row_n[4]}
N 2380 -1050 2380 -1020 {lab=GND}
N 2580 -2000 2580 -1960 {lab=row_n[5]}
N 2580 -1900 2580 -1870 {lab=GND}
N 2580 -1800 2580 -1760 {lab=row_n[6]}
N 2580 -1700 2580 -1670 {lab=GND}
N 2580 -1590 2580 -1550 {lab=row_n[7]}
N 2580 -1490 2580 -1460 {lab=GND}
N 2580 -1360 2580 -1320 {lab=row_n[8]}
N 2580 -1260 2580 -1230 {lab=GND}
N 2580 -1150 2580 -1110 {lab=row_n[9]}
N 2580 -1050 2580 -1020 {lab=GND}
N 1870 -2000 1870 -1960 {lab=rowon_n[0]}
N 1870 -1900 1870 -1870 {lab=GND}
N 1870 -1790 1870 -1750 {lab=rowon_n[1]}
N 1870 -1690 1870 -1660 {lab=GND}
N 1870 -1580 1870 -1540 {lab=rowon_n[2]}
N 1870 -1480 1870 -1450 {lab=GND}
N 1870 -1360 1870 -1320 {lab=rowon_n[3]}
N 1870 -1260 1870 -1230 {lab=GND}
N 1870 -1150 1870 -1110 {lab=rowon_n[4]}
N 1870 -1050 1870 -1020 {lab=GND}
N 2070 -2000 2070 -1960 {lab=rowon_n[5]}
N 2070 -1900 2070 -1870 {lab=GND}
N 2070 -1800 2070 -1760 {lab=rowon_n[6]}
N 2070 -1700 2070 -1670 {lab=GND}
N 2070 -1590 2070 -1550 {lab=rowon_n[7]}
N 2070 -1490 2070 -1460 {lab=GND}
N 2070 -1360 2070 -1320 {lab=rowon_n[8]}
N 2070 -1260 2070 -1230 {lab=GND}
N 2070 -1150 2070 -1110 {lab=rowon_n[9]}
N 2070 -1050 2070 -1020 {lab=GND}
N 1340 -1990 1340 -1950 {lab=rowoff_n[0]}
N 1340 -1890 1340 -1860 {lab=GND}
N 1340 -1780 1340 -1740 {lab=rowoff_n[1]}
N 1340 -1680 1340 -1650 {lab=GND}
N 1340 -1570 1340 -1530 {lab=rowoff_n[2]}
N 1340 -1470 1340 -1440 {lab=GND}
N 1340 -1350 1340 -1310 {lab=rowoff_n[3]}
N 1340 -1250 1340 -1220 {lab=GND}
N 1340 -1140 1340 -1100 {lab=rowoff_n[4]}
N 1340 -1040 1340 -1010 {lab=GND}
N 1540 -1990 1540 -1950 {lab=rowoff_n[5]}
N 1540 -1890 1540 -1860 {lab=GND}
N 1540 -1790 1540 -1750 {lab=rowoff_n[6]}
N 1540 -1690 1540 -1660 {lab=GND}
N 1540 -1580 1540 -1540 {lab=rowoff_n[7]}
N 1540 -1480 1540 -1450 {lab=GND}
N 1540 -1350 1540 -1310 {lab=rowoff_n[8]}
N 1540 -1250 1540 -1220 {lab=GND}
N 1540 -1140 1540 -1100 {lab=rowoff_n[9]}
N 1540 -1040 1540 -1010 {lab=GND}
N 1340 -850 1340 -820 {lab=col_n[0]}
N 1340 -760 1340 -740 {lab=GND}
N 1340 -690 1340 -660 {lab=col_n[1]}
N 1340 -600 1340 -580 {lab=GND}
N 1340 -520 1340 -490 {lab=col_n[2]}
N 1340 -430 1340 -410 {lab=GND}
N 1340 -360 1340 -330 {lab=col_n[3]}
N 1340 -270 1340 -250 {lab=GND}
N 1540 -860 1540 -830 {lab=col_n[4]}
N 1540 -770 1540 -750 {lab=GND}
N 1540 -700 1540 -670 {lab=col_n[5]}
N 1540 -610 1540 -590 {lab=GND}
N 1540 -530 1540 -500 {lab=col_n[6]}
N 1540 -440 1540 -420 {lab=GND}
N 1540 -370 1540 -340 {lab=col_n[7]}
N 1540 -280 1540 -260 {lab=GND}
N 1750 -860 1750 -830 {lab=col_n[8]}
N 1750 -770 1750 -750 {lab=GND}
N 1750 -700 1750 -670 {lab=col_n[9]}
N 1750 -610 1750 -590 {lab=GND}
N 1750 -530 1750 -500 {lab=col_n[10]}
N 1750 -440 1750 -420 {lab=GND}
N 1750 -370 1750 -340 {lab=col_n[11]}
N 1750 -280 1750 -260 {lab=GND}
N 1530 -180 1530 -150 {lab=col_n[12]}
N 1530 -90 1530 -70 {lab=GND}
N 1920 -860 1920 -840 {lab=col[0]}
N 1920 -780 1920 -760 {lab=GND}
N 1920 -710 1920 -690 {lab=col[1]}
N 1920 -630 1920 -610 {lab=GND}
N 1920 -560 1920 -540 {lab=col[2]}
N 1920 -480 1920 -460 {lab=GND}
N 1920 -400 1920 -380 {lab=col[3]}
N 1920 -320 1920 -300 {lab=GND}
N 2040 -870 2040 -850 {lab=col[4]}
N 2040 -790 2040 -770 {lab=GND}
N 2040 -710 2040 -690 {lab=col[5]}
N 2040 -630 2040 -610 {lab=GND}
N 2040 -550 2040 -530 {lab=col[6]}
N 2040 -470 2040 -450 {lab=GND}
N 2030 -400 2030 -380 {lab=col[7]}
N 2030 -320 2030 -300 {lab=GND}
N 2170 -890 2170 -870 {lab=col[8]}
N 2170 -810 2170 -790 {lab=GND}
N 2160 -720 2160 -700 {lab=col[9]}
N 2160 -640 2160 -620 {lab=GND}
N 2160 -550 2160 -530 {lab=col[10]}
N 2160 -470 2160 -450 {lab=GND}
N 2160 -390 2160 -370 {lab=col[11]}
N 2160 -310 2160 -290 {lab=GND}
N 2280 -730 2280 -710 {lab=col[12]}
N 2280 -650 2280 -630 {lab=GND}
N 3030 -1150 3030 -1120 {lab=GND}
N 3180 -1150 3180 -1120 {lab=GND}
N 3320 -1150 3320 -1120 {lab=GND}
N 3030 -1230 3030 -1210 {lab=en_bit_n[0]}
N 3180 -1230 3180 -1210 {lab=en_bit_n[1]}
N 3320 -1230 3320 -1210 {lab=en_bit_n[2]}
N 3490 -1150 3490 -1120 {lab=GND}
N 3490 -1240 3490 -1210 {lab=en_C0_n}
N 4120 -1890 4230 -1890 {lab=#net25}
N 4230 -1890 4420 -1890 {lab=#net25}
N 4520 -1890 4600 -1890 {lab=vcm}
N 4420 -1830 4420 -1800 {lab=#net27}
N 4470 -1830 4470 -1800 {lab=#net27}
N 4520 -1830 4520 -1800 {lab=#net27}
N 4420 -1800 4520 -1800 {lab=#net27}
N 740 -3340 760 -3340 {
lab=VDD}
N 740 -3320 760 -3320 {
lab=VSS}
N 740 -3300 760 -3300 {
lab=sample}
N 740 -3280 760 -3280 {
lab=sample_n}
N 740 -3360 760 -3360 {
lab=VDD}
N 800 -3200 800 -3190 {
lab=VSS}
N 880 -3200 880 -3190 {
lab=VDD}
N 900 -3200 900 -3190 {
lab=VSS}
N 1120 -3200 1120 -3190 {
lab=VSS}
N 1200 -3200 1200 -3180 {
lab=col_n[0]}
N 1220 -3200 1220 -3180 {
lab=col[0]}
N 1450 -3200 1450 -3190 {
lab=VSS}
N 1530 -3200 1530 -3180 {
lab=col_n[1]}
N 1480 -3200 1480 -3190 {
lab=en_C0_n}
N 1480 -3190 1480 -3180 {
lab=en_C0_n}
N 1550 -3200 1550 -3180 {
lab=col[1]}
N 800 -3520 800 -3510 {
lab=VSS}
N 800 -3820 800 -3810 {
lab=VSS}
N 1120 -3820 1120 -3810 {
lab=VSS}
N 1120 -3520 1120 -3510 {
lab=VSS}
N 1450 -3520 1450 -3510 {
lab=VSS}
N 1450 -3820 1450 -3810 {
lab=VSS}
N 1800 -3820 1800 -3810 {
lab=VSS}
N 1800 -3520 1800 -3510 {
lab=VSS}
N 2150 -3520 2150 -3510 {
lab=VSS}
N 2150 -3820 2150 -3810 {
lab=VSS}
N 2500 -3820 2500 -3810 {
lab=VSS}
N 2840 -3820 2840 -3810 {
lab=VSS}
N 2840 -3520 2840 -3510 {
lab=VSS}
N 2500 -3520 2500 -3510 {
lab=VSS}
N 3190 -3820 3190 -3810 {
lab=VSS}
N 3190 -3520 3190 -3510 {
lab=VSS}
N 3550 -3820 3550 -3810 {
lab=VSS}
N 3880 -3820 3880 -3810 {
lab=VSS}
N 3550 -3520 3550 -3510 {
lab=VSS}
N 3880 -3520 3880 -3510 {
lab=VSS}
N 4210 -3520 4210 -3510 {
lab=VSS}
N 4210 -3820 4210 -3810 {
lab=VSS}
N 4560 -3820 4560 -3810 {
lab=VSS}
N 4910 -3820 4910 -3810 {
lab=VSS}
N 4560 -3520 4560 -3510 {
lab=VSS}
N 4910 -3520 4910 -3510 {
lab=VSS}
N 5250 -3820 5250 -3810 {
lab=VSS}
N 5250 -3520 5250 -3510 {
lab=VSS}
N 5590 -3820 5590 -3810 {
lab=VSS}
N 5590 -3520 5590 -3510 {
lab=VSS}
N 2150 -3200 2150 -3190 {
lab=VSS}
N 2230 -3200 2230 -3180 {
lab=col_n[3]}
N 2250 -3200 2250 -3180 {
lab=col[3]}
N 1800 -3200 1800 -3190 {
lab=VSS}
N 1880 -3200 1880 -3180 {
lab=col_n[2]}
N 1900 -3200 1900 -3180 {
lab=col[2]}
N 2500 -3200 2500 -3190 {
lab=VSS}
N 2580 -3200 2580 -3180 {
lab=col_n[4]}
N 2600 -3200 2600 -3180 {
lab=col[4]}
N 2840 -3200 2840 -3190 {
lab=VSS}
N 2920 -3200 2920 -3180 {
lab=col_n[5]}
N 2940 -3200 2940 -3180 {
lab=col[5]}
N 3190 -3200 3190 -3190 {
lab=VSS}
N 3270 -3200 3270 -3180 {
lab=col_n[6]}
N 2870 -3200 2870 -3180 {
lab=en_bit_n[1]}
N 3290 -3200 3290 -3180 {
lab=col[6]}
N 3550 -3200 3550 -3190 {
lab=VSS}
N 3630 -3200 3630 -3180 {
lab=col_n[7]}
N 3220 -3200 3220 -3180 {
lab=en_bit_n[2]}
N 3650 -3200 3650 -3180 {
lab=col[7]}
N 3880 -3200 3880 -3190 {
lab=VSS}
N 3960 -3200 3960 -3180 {
lab=col_n[8]}
N 3580 -3200 3580 -3180 {
lab=en_bit_n[0]}
N 3980 -3200 3980 -3180 {
lab=col[8]}
N 4290 -3200 4290 -3180 {
lab=col_n[9]}
N 4310 -3200 4310 -3180 {
lab=col[9]}
N 4210 -3200 4210 -3190 {lab=VSS}
N 4640 -3200 4640 -3180 {
lab=col_n[10]}
N 4660 -3200 4660 -3180 {
lab=col[10]}
N 4560 -3200 4560 -3190 {lab=VSS}
N 4990 -3200 4990 -3180 {
lab=col_n[11]}
N 5010 -3200 5010 -3180 {
lab=col[11]}
N 4910 -3200 4910 -3190 {lab=VSS}
N 5330 -3200 5330 -3180 {
lab=col_n[12]}
N 5350 -3200 5350 -3180 {
lab=col[12]}
N 5250 -3200 5250 -3190 {lab=VSS}
N 5590 -3200 5590 -3190 {
lab=VSS}
N 5310 -3200 5310 -3180 {
lab=sw}
N 5390 -3200 5390 -3180 {
lab=sw_n}
N 5370 -3200 5370 -3180 {
lab=analog_in}
N 5670 -3200 5670 -3180 {
lab=VDD}
N 5690 -3200 5690 -3180 {
lab=VSS}
N 820 -3440 820 -3420 {
lab=vcm}
N 800 -3430 800 -3420 {
lab=VDD}
N 860 -3440 860 -3420 {
lab=ctop}
N 1140 -3440 1140 -3420 {
lab=vcm}
N 1120 -3430 1120 -3420 {
lab=VDD}
N 1180 -3440 1180 -3420 {
lab=ctop}
N 1470 -3440 1470 -3420 {
lab=vcm}
N 1450 -3430 1450 -3420 {
lab=VDD}
N 1510 -3440 1510 -3420 {
lab=ctop}
N 1820 -3440 1820 -3420 {
lab=vcm}
N 1800 -3430 1800 -3420 {
lab=VDD}
N 1860 -3440 1860 -3420 {
lab=ctop}
N 2170 -3440 2170 -3420 {
lab=vcm}
N 2150 -3430 2150 -3420 {
lab=VDD}
N 2210 -3440 2210 -3420 {
lab=ctop}
N 2520 -3440 2520 -3420 {
lab=vcm}
N 2500 -3430 2500 -3420 {
lab=VDD}
N 2560 -3440 2560 -3420 {
lab=ctop}
N 2860 -3440 2860 -3420 {
lab=vcm}
N 2840 -3430 2840 -3420 {
lab=VDD}
N 2900 -3440 2900 -3420 {
lab=ctop}
N 3210 -3440 3210 -3420 {
lab=vcm}
N 3190 -3430 3190 -3420 {
lab=VDD}
N 3250 -3440 3250 -3420 {
lab=ctop}
N 3570 -3440 3570 -3420 {
lab=vcm}
N 3550 -3430 3550 -3420 {
lab=VDD}
N 3610 -3440 3610 -3420 {
lab=ctop}
N 3900 -3440 3900 -3420 {
lab=vcm}
N 3880 -3430 3880 -3420 {
lab=VDD}
N 3940 -3440 3940 -3420 {
lab=ctop}
N 4230 -3440 4230 -3420 {
lab=vcm}
N 4210 -3430 4210 -3420 {
lab=VDD}
N 4270 -3440 4270 -3420 {
lab=ctop}
N 4580 -3440 4580 -3420 {
lab=vcm}
N 4560 -3430 4560 -3420 {
lab=VDD}
N 4620 -3440 4620 -3420 {
lab=ctop}
N 4930 -3440 4930 -3420 {
lab=vcm}
N 4910 -3430 4910 -3420 {
lab=VDD}
N 4970 -3440 4970 -3420 {
lab=ctop}
N 5270 -3440 5270 -3420 {
lab=vcm}
N 5250 -3430 5250 -3420 {
lab=VDD}
N 5310 -3440 5310 -3420 {
lab=ctop}
N 5610 -3440 5610 -3420 {
lab=vcm}
N 5590 -3430 5590 -3420 {
lab=VDD}
N 5650 -3440 5650 -3420 {
lab=ctop}
N 5610 -3760 5610 -3740 {
lab=vcm}
N 5590 -3750 5590 -3740 {
lab=VDD}
N 5650 -3760 5650 -3740 {
lab=ctop}
N 5610 -4060 5610 -4040 {
lab=vcm}
N 5590 -4050 5590 -4040 {
lab=VDD}
N 5650 -4060 5650 -4040 {
lab=ctop}
N 4930 -4060 4930 -4040 {
lab=vcm}
N 4910 -4050 4910 -4040 {
lab=VDD}
N 4970 -4060 4970 -4040 {
lab=ctop}
N 5270 -4060 5270 -4040 {
lab=vcm}
N 5250 -4050 5250 -4040 {
lab=VDD}
N 5310 -4060 5310 -4040 {
lab=ctop}
N 5270 -3760 5270 -3740 {
lab=vcm}
N 5250 -3750 5250 -3740 {
lab=VDD}
N 5310 -3760 5310 -3740 {
lab=ctop}
N 4930 -3760 4930 -3740 {
lab=vcm}
N 4910 -3750 4910 -3740 {
lab=VDD}
N 4970 -3760 4970 -3740 {
lab=ctop}
N 4580 -3760 4580 -3740 {
lab=vcm}
N 4560 -3750 4560 -3740 {
lab=VDD}
N 4620 -3760 4620 -3740 {
lab=ctop}
N 4580 -4060 4580 -4040 {
lab=vcm}
N 4560 -4050 4560 -4040 {
lab=VDD}
N 4620 -4060 4620 -4040 {
lab=ctop}
N 4230 -4060 4230 -4040 {
lab=vcm}
N 4210 -4050 4210 -4040 {
lab=VDD}
N 4270 -4060 4270 -4040 {
lab=ctop}
N 4230 -3760 4230 -3740 {
lab=vcm}
N 4210 -3750 4210 -3740 {
lab=VDD}
N 4270 -3760 4270 -3740 {
lab=ctop}
N 3900 -3760 3900 -3740 {
lab=vcm}
N 3880 -3750 3880 -3740 {
lab=VDD}
N 3940 -3760 3940 -3740 {
lab=ctop}
N 3900 -4060 3900 -4040 {
lab=vcm}
N 3880 -4050 3880 -4040 {
lab=VDD}
N 3940 -4060 3940 -4040 {
lab=ctop}
N 3570 -4060 3570 -4040 {
lab=vcm}
N 3550 -4050 3550 -4040 {
lab=VDD}
N 3610 -4060 3610 -4040 {
lab=ctop}
N 3570 -3760 3570 -3740 {
lab=vcm}
N 3550 -3750 3550 -3740 {
lab=VDD}
N 3610 -3760 3610 -3740 {
lab=ctop}
N 3210 -3760 3210 -3740 {
lab=vcm}
N 3190 -3750 3190 -3740 {
lab=VDD}
N 3250 -3760 3250 -3740 {
lab=ctop}
N 3210 -4060 3210 -4040 {
lab=vcm}
N 3190 -4050 3190 -4040 {
lab=VDD}
N 3250 -4060 3250 -4040 {
lab=ctop}
N 2860 -4060 2860 -4040 {
lab=vcm}
N 2840 -4050 2840 -4040 {
lab=VDD}
N 2900 -4060 2900 -4040 {
lab=ctop}
N 2860 -3760 2860 -3740 {
lab=vcm}
N 2840 -3750 2840 -3740 {
lab=VDD}
N 2900 -3760 2900 -3740 {
lab=ctop}
N 2520 -3760 2520 -3740 {
lab=vcm}
N 2500 -3750 2500 -3740 {
lab=VDD}
N 2560 -3760 2560 -3740 {
lab=ctop}
N 2520 -4060 2520 -4040 {
lab=vcm}
N 2500 -4050 2500 -4040 {
lab=VDD}
N 2560 -4060 2560 -4040 {
lab=ctop}
N 2170 -4060 2170 -4040 {
lab=vcm}
N 2150 -4050 2150 -4040 {
lab=VDD}
N 2210 -4060 2210 -4040 {
lab=ctop}
N 2170 -3760 2170 -3740 {
lab=vcm}
N 2150 -3750 2150 -3740 {
lab=VDD}
N 2210 -3760 2210 -3740 {
lab=ctop}
N 1820 -3760 1820 -3740 {
lab=vcm}
N 1800 -3750 1800 -3740 {
lab=VDD}
N 1860 -3760 1860 -3740 {
lab=ctop}
N 1820 -4060 1820 -4040 {
lab=vcm}
N 1800 -4050 1800 -4040 {
lab=VDD}
N 1860 -4060 1860 -4040 {
lab=ctop}
N 1470 -4060 1470 -4040 {
lab=vcm}
N 1450 -4050 1450 -4040 {
lab=VDD}
N 1510 -4060 1510 -4040 {
lab=ctop}
N 1140 -4060 1140 -4040 {
lab=vcm}
N 1120 -4050 1120 -4040 {
lab=VDD}
N 1180 -4060 1180 -4040 {
lab=ctop}
N 1140 -3760 1140 -3740 {
lab=vcm}
N 1120 -3750 1120 -3740 {
lab=VDD}
N 1180 -3760 1180 -3740 {
lab=ctop}
N 1470 -3760 1470 -3740 {
lab=vcm}
N 1450 -3750 1450 -3740 {
lab=VDD}
N 1510 -3760 1510 -3740 {
lab=ctop}
N 820 -4060 820 -4040 {
lab=vcm}
N 800 -4050 800 -4040 {
lab=VDD}
N 860 -4060 860 -4040 {
lab=ctop}
N 820 -3760 820 -3740 {
lab=vcm}
N 800 -3750 800 -3740 {
lab=VDD}
N 860 -3760 860 -3740 {
lab=ctop}
N 740 -3600 760 -3600 {
lab=sample_n}
N 740 -3620 760 -3620 {
lab=sample}
N 740 -3640 760 -3640 {
lab=rowon_n[0]}
N 740 -3660 760 -3660 {
lab=row_n[0]}
N 740 -3680 760 -3680 {
lab=rowoff_n[0]}
N 740 -3900 760 -3900 {
lab=sample_n}
N 740 -3920 760 -3920 {
lab=sample}
N 740 -3940 760 -3940 {
lab=rowon_n[1]}
N 740 -3960 760 -3960 {
lab=row_n[1]}
N 740 -3980 760 -3980 {
lab=rowoff_n[1]}
N 980 -3920 1080 -3920 {lab=#net1}
N 980 -3900 1080 -3900 {lab=#net2}
N 760 -3980 770 -3990 {lab=rowoff_n[1]}
N 770 -3990 990 -3990 {lab=rowoff_n[1]}
N 990 -3990 1000 -3980 {lab=rowoff_n[1]}
N 1000 -3980 1080 -3980 {lab=rowoff_n[1]}
N 760 -3960 770 -3970 {lab=row_n[1]}
N 770 -3970 990 -3970 {lab=row_n[1]}
N 990 -3970 1000 -3960 {lab=row_n[1]}
N 1000 -3960 1080 -3960 {lab=row_n[1]}
N 760 -3940 770 -3950 {lab=rowon_n[1]}
N 770 -3950 990 -3950 {lab=rowon_n[1]}
N 990 -3950 1000 -3940 {lab=rowon_n[1]}
N 1000 -3940 1080 -3940 {lab=rowon_n[1]}
N 1080 -3980 1090 -3990 {lab=rowoff_n[1]}
N 1080 -3960 1090 -3970 {lab=row_n[1]}
N 1090 -3970 1290 -3970 {lab=row_n[1]}
N 1290 -3970 1300 -3960 {lab=row_n[1]}
N 1300 -3960 1410 -3960 {lab=row_n[1]}
N 1090 -3990 1290 -3990 {lab=rowoff_n[1]}
N 1290 -3990 1300 -3980 {lab=rowoff_n[1]}
N 1300 -3980 1410 -3980 {lab=rowoff_n[1]}
N 1080 -3940 1090 -3950 {lab=rowon_n[1]}
N 1090 -3950 1290 -3950 {lab=rowon_n[1]}
N 1290 -3950 1300 -3940 {lab=rowon_n[1]}
N 1300 -3940 1410 -3940 {lab=rowon_n[1]}
N 1080 -3920 1090 -3930 {lab=#net1}
N 1090 -3930 1290 -3930 {lab=#net1}
N 1290 -3930 1300 -3920 {lab=#net1}
N 1300 -3920 1410 -3920 {lab=#net1}
N 1080 -3900 1090 -3910 {lab=#net2}
N 1090 -3910 1290 -3910 {lab=#net2}
N 1290 -3910 1300 -3900 {lab=#net2}
N 1300 -3900 1410 -3900 {lab=#net2}
N 1410 -3960 1420 -3970 {lab=row_n[1]}
N 1420 -3970 1620 -3970 {lab=row_n[1]}
N 1620 -3970 1630 -3960 {lab=row_n[1]}
N 1630 -3960 1760 -3960 {lab=row_n[1]}
N 1410 -3940 1420 -3950 {lab=rowon_n[1]}
N 1420 -3950 1620 -3950 {lab=rowon_n[1]}
N 1620 -3950 1630 -3940 {lab=rowon_n[1]}
N 1630 -3940 1760 -3940 {lab=rowon_n[1]}
N 1410 -3920 1420 -3930 {lab=#net1}
N 1420 -3930 1620 -3930 {lab=#net1}
N 1620 -3930 1630 -3920 {lab=#net1}
N 1630 -3920 1760 -3920 {lab=#net1}
N 1410 -3900 1430 -3910 {lab=#net2}
N 1430 -3910 1620 -3910 {lab=#net2}
N 1620 -3910 1630 -3900 {lab=#net2}
N 1630 -3900 1760 -3900 {lab=#net2}
N 1410 -3980 1420 -3990 {lab=rowoff_n[1]}
N 1420 -3990 1620 -3990 {lab=rowoff_n[1]}
N 1620 -3990 1630 -3980 {lab=rowoff_n[1]}
N 1630 -3980 1760 -3980 {lab=rowoff_n[1]}
N 1760 -3980 1770 -3990 {lab=rowoff_n[1]}
N 1770 -3990 1970 -3990 {lab=rowoff_n[1]}
N 1970 -3990 1980 -3980 {lab=rowoff_n[1]}
N 1980 -3980 2110 -3980 {lab=rowoff_n[1]}
N 1760 -3960 1770 -3970 {lab=row_n[1]}
N 1770 -3970 1970 -3970 {lab=row_n[1]}
N 1970 -3970 1980 -3960 {lab=row_n[1]}
N 1980 -3960 2110 -3960 {lab=row_n[1]}
N 1760 -3940 1770 -3950 {lab=rowon_n[1]}
N 1770 -3950 1970 -3950 {lab=rowon_n[1]}
N 1970 -3950 1980 -3940 {lab=rowon_n[1]}
N 1980 -3940 2110 -3940 {lab=rowon_n[1]}
N 1760 -3920 1770 -3930 {lab=#net1}
N 1770 -3930 1970 -3930 {lab=#net1}
N 1970 -3930 1980 -3920 {lab=#net1}
N 1980 -3920 2110 -3920 {lab=#net1}
N 1760 -3900 1770 -3910 {lab=#net2}
N 1770 -3910 1970 -3910 {lab=#net2}
N 1970 -3910 1980 -3900 {lab=#net2}
N 1980 -3900 2110 -3900 {lab=#net2}
N 2110 -3980 2120 -3990 {lab=rowoff_n[1]}
N 2120 -3990 2320 -3990 {lab=rowoff_n[1]}
N 2320 -3990 2330 -3980 {lab=rowoff_n[1]}
N 2330 -3980 2460 -3980 {lab=rowoff_n[1]}
N 2110 -3960 2120 -3970 {lab=row_n[1]}
N 2120 -3970 2320 -3970 {lab=row_n[1]}
N 2320 -3970 2330 -3960 {lab=row_n[1]}
N 2330 -3960 2460 -3960 {lab=row_n[1]}
N 2110 -3940 2120 -3950 {lab=rowon_n[1]}
N 2120 -3950 2320 -3950 {lab=rowon_n[1]}
N 2320 -3950 2330 -3940 {lab=rowon_n[1]}
N 2330 -3940 2460 -3940 {lab=rowon_n[1]}
N 2320 -3930 2330 -3920 {lab=#net1}
N 2330 -3920 2460 -3920 {lab=#net1}
N 2110 -3900 2120 -3910 {lab=#net2}
N 2120 -3910 2320 -3910 {lab=#net2}
N 2320 -3910 2330 -3900 {lab=#net2}
N 2330 -3900 2460 -3900 {lab=#net2}
N 2110 -3920 2120 -3930 {lab=#net1}
N 2120 -3930 2320 -3930 {lab=#net1}
N 2460 -3980 2470 -3990 {lab=rowoff_n[1]}
N 2470 -3990 2670 -3990 {lab=rowoff_n[1]}
N 2670 -3990 2680 -3980 {lab=rowoff_n[1]}
N 2680 -3980 2800 -3980 {lab=rowoff_n[1]}
N 2460 -3960 2470 -3970 {lab=row_n[1]}
N 2470 -3970 2670 -3970 {lab=row_n[1]}
N 2670 -3970 2680 -3960 {lab=row_n[1]}
N 2680 -3960 2800 -3960 {lab=row_n[1]}
N 2460 -3940 2470 -3950 {lab=rowon_n[1]}
N 2470 -3950 2670 -3950 {lab=rowon_n[1]}
N 2670 -3950 2680 -3940 {lab=rowon_n[1]}
N 2680 -3940 2800 -3940 {lab=rowon_n[1]}
N 2460 -3920 2470 -3930 {lab=#net1}
N 2470 -3930 2670 -3930 {lab=#net1}
N 2670 -3930 2680 -3920 {lab=#net1}
N 2680 -3920 2800 -3920 {lab=#net1}
N 2460 -3900 2470 -3910 {lab=#net2}
N 2470 -3910 2670 -3910 {lab=#net2}
N 2670 -3910 2680 -3900 {lab=#net2}
N 2680 -3900 2800 -3900 {lab=#net2}
N 2800 -3980 2810 -3990 {lab=rowoff_n[1]}
N 2810 -3990 3010 -3990 {lab=rowoff_n[1]}
N 3010 -3990 3020 -3980 {lab=rowoff_n[1]}
N 3020 -3980 3150 -3980 {lab=rowoff_n[1]}
N 2800 -3960 2810 -3970 {lab=row_n[1]}
N 2810 -3970 3010 -3970 {lab=row_n[1]}
N 3010 -3970 3020 -3960 {lab=row_n[1]}
N 3020 -3960 3150 -3960 {lab=row_n[1]}
N 2800 -3940 2810 -3950 {lab=rowon_n[1]}
N 2810 -3950 3010 -3950 {lab=rowon_n[1]}
N 3010 -3950 3020 -3940 {lab=rowon_n[1]}
N 3020 -3940 3150 -3940 {lab=rowon_n[1]}
N 2800 -3920 2810 -3930 {lab=#net1}
N 2810 -3930 3010 -3930 {lab=#net1}
N 2800 -3900 2810 -3910 {lab=#net2}
N 2810 -3910 3010 -3910 {lab=#net2}
N 3010 -3910 3020 -3900 {lab=#net2}
N 3020 -3900 3150 -3900 {lab=#net2}
N 3010 -3930 3020 -3920 {lab=#net1}
N 3020 -3920 3150 -3920 {lab=#net1}
N 3150 -3980 3160 -3990 {lab=rowoff_n[1]}
N 3160 -3990 3360 -3990 {lab=rowoff_n[1]}
N 3360 -3990 3370 -3980 {lab=rowoff_n[1]}
N 3370 -3980 3510 -3980 {lab=rowoff_n[1]}
N 3150 -3960 3160 -3970 {lab=row_n[1]}
N 3160 -3970 3360 -3970 {lab=row_n[1]}
N 3360 -3970 3370 -3960 {lab=row_n[1]}
N 3370 -3960 3510 -3960 {lab=row_n[1]}
N 3150 -3940 3160 -3950 {lab=rowon_n[1]}
N 3160 -3950 3360 -3950 {lab=rowon_n[1]}
N 3360 -3950 3370 -3940 {lab=rowon_n[1]}
N 3370 -3940 3510 -3940 {lab=rowon_n[1]}
N 3150 -3920 3160 -3930 {lab=#net1}
N 3160 -3930 3360 -3930 {lab=#net1}
N 3360 -3930 3370 -3920 {lab=#net1}
N 3370 -3920 3510 -3920 {lab=#net1}
N 3150 -3900 3160 -3910 {lab=#net2}
N 3160 -3910 3360 -3910 {lab=#net2}
N 3360 -3910 3370 -3900 {lab=#net2}
N 3370 -3900 3510 -3900 {lab=#net2}
N 3510 -3980 3520 -3990 {lab=rowoff_n[1]}
N 3520 -3990 3720 -3990 {lab=rowoff_n[1]}
N 3720 -3990 3730 -3980 {lab=rowoff_n[1]}
N 3730 -3980 3840 -3980 {lab=rowoff_n[1]}
N 3510 -3960 3520 -3970 {lab=row_n[1]}
N 3520 -3970 3720 -3970 {lab=row_n[1]}
N 3720 -3970 3730 -3960 {lab=row_n[1]}
N 3730 -3960 3840 -3960 {lab=row_n[1]}
N 3510 -3940 3520 -3950 {lab=rowon_n[1]}
N 3520 -3950 3720 -3950 {lab=rowon_n[1]}
N 3720 -3950 3730 -3940 {lab=rowon_n[1]}
N 3730 -3940 3840 -3940 {lab=rowon_n[1]}
N 3510 -3920 3520 -3930 {lab=#net1}
N 3520 -3930 3720 -3930 {lab=#net1}
N 3720 -3930 3730 -3920 {lab=#net1}
N 3730 -3920 3840 -3920 {lab=#net1}
N 3510 -3900 3520 -3910 {lab=#net2}
N 3520 -3910 3720 -3910 {lab=#net2}
N 3720 -3910 3730 -3900 {lab=#net2}
N 3730 -3900 3840 -3900 {lab=#net2}
N 3840 -3980 3850 -3990 {lab=rowoff_n[1]}
N 3850 -3990 4050 -3990 {lab=rowoff_n[1]}
N 4050 -3990 4060 -3980 {lab=rowoff_n[1]}
N 4060 -3980 4170 -3980 {lab=rowoff_n[1]}
N 3840 -3960 3850 -3970 {lab=row_n[1]}
N 3850 -3970 4050 -3970 {lab=row_n[1]}
N 4050 -3970 4060 -3960 {lab=row_n[1]}
N 4060 -3960 4170 -3960 {lab=row_n[1]}
N 3840 -3940 3850 -3950 {lab=rowon_n[1]}
N 3850 -3950 4050 -3950 {lab=rowon_n[1]}
N 4050 -3950 4060 -3940 {lab=rowon_n[1]}
N 4060 -3940 4170 -3940 {lab=rowon_n[1]}
N 3840 -3920 3850 -3930 {lab=#net1}
N 3850 -3930 4050 -3930 {lab=#net1}
N 4050 -3930 4060 -3920 {lab=#net1}
N 4060 -3920 4170 -3920 {lab=#net1}
N 3840 -3900 3850 -3910 {lab=#net2}
N 3850 -3910 4050 -3910 {lab=#net2}
N 4050 -3910 4070 -3900 {lab=#net2}
N 4070 -3900 4170 -3900 {lab=#net2}
N 4170 -3980 4180 -3990 {lab=rowoff_n[1]}
N 4180 -3990 4380 -3990 {lab=rowoff_n[1]}
N 4380 -3990 4390 -3980 {lab=rowoff_n[1]}
N 4390 -3980 4520 -3980 {lab=rowoff_n[1]}
N 4170 -3960 4180 -3970 {lab=row_n[1]}
N 4180 -3970 4380 -3970 {lab=row_n[1]}
N 4380 -3970 4390 -3960 {lab=row_n[1]}
N 4390 -3960 4520 -3960 {lab=row_n[1]}
N 4170 -3940 4180 -3950 {lab=rowon_n[1]}
N 4180 -3950 4380 -3950 {lab=rowon_n[1]}
N 4380 -3950 4390 -3940 {lab=rowon_n[1]}
N 4390 -3940 4520 -3940 {lab=rowon_n[1]}
N 4170 -3920 4180 -3930 {lab=#net1}
N 4180 -3930 4380 -3930 {lab=#net1}
N 4380 -3930 4390 -3920 {lab=#net1}
N 4390 -3920 4520 -3920 {lab=#net1}
N 4170 -3900 4180 -3910 {lab=#net2}
N 4180 -3910 4380 -3910 {lab=#net2}
N 4380 -3910 4390 -3900 {lab=#net2}
N 4390 -3900 4520 -3900 {lab=#net2}
N 4520 -3980 4530 -3990 {lab=rowoff_n[1]}
N 4530 -3990 4730 -3990 {lab=rowoff_n[1]}
N 4730 -3990 4740 -3980 {lab=rowoff_n[1]}
N 4740 -3980 4870 -3980 {lab=rowoff_n[1]}
N 4520 -3960 4530 -3970 {lab=row_n[1]}
N 4530 -3970 4730 -3970 {lab=row_n[1]}
N 4520 -3940 4530 -3950 {lab=rowon_n[1]}
N 4530 -3950 4730 -3950 {lab=rowon_n[1]}
N 4730 -3950 4740 -3940 {lab=rowon_n[1]}
N 4740 -3940 4870 -3940 {lab=rowon_n[1]}
N 4730 -3970 4740 -3960 {lab=row_n[1]}
N 4740 -3960 4870 -3960 {lab=row_n[1]}
N 4520 -3920 4530 -3930 {lab=#net1}
N 4530 -3930 4730 -3930 {lab=#net1}
N 4730 -3930 4740 -3920 {lab=#net1}
N 4740 -3920 4870 -3920 {lab=#net1}
N 4520 -3900 4530 -3910 {lab=#net2}
N 4530 -3910 4730 -3910 {lab=#net2}
N 4730 -3910 4740 -3900 {lab=#net2}
N 4740 -3900 4870 -3900 {lab=#net2}
N 4870 -3980 4880 -3990 {lab=rowoff_n[1]}
N 4880 -3990 5080 -3990 {lab=rowoff_n[1]}
N 5080 -3990 5090 -3980 {lab=rowoff_n[1]}
N 5090 -3980 5210 -3980 {lab=rowoff_n[1]}
N 4870 -3960 4880 -3970 {lab=row_n[1]}
N 4880 -3970 5080 -3970 {lab=row_n[1]}
N 5080 -3970 5090 -3960 {lab=row_n[1]}
N 5090 -3960 5210 -3960 {lab=row_n[1]}
N 4870 -3940 4880 -3950 {lab=rowon_n[1]}
N 4880 -3950 5080 -3950 {lab=rowon_n[1]}
N 5080 -3950 5090 -3940 {lab=rowon_n[1]}
N 5090 -3940 5210 -3940 {lab=rowon_n[1]}
N 4870 -3920 4880 -3930 {lab=#net1}
N 4880 -3930 5080 -3930 {lab=#net1}
N 5080 -3930 5090 -3920 {lab=#net1}
N 5090 -3920 5210 -3920 {lab=#net1}
N 4870 -3900 4880 -3910 {lab=#net2}
N 4880 -3910 5080 -3910 {lab=#net2}
N 5080 -3910 5090 -3900 {lab=#net2}
N 5090 -3900 5210 -3900 {lab=#net2}
N 5210 -3980 5220 -3990 {lab=rowoff_n[1]}
N 5220 -3990 5420 -3990 {lab=rowoff_n[1]}
N 5420 -3990 5430 -3980 {lab=rowoff_n[1]}
N 5430 -3980 5550 -3980 {lab=rowoff_n[1]}
N 5210 -3960 5220 -3970 {lab=row_n[1]}
N 5220 -3970 5420 -3970 {lab=row_n[1]}
N 5420 -3970 5430 -3960 {lab=row_n[1]}
N 5430 -3960 5550 -3960 {lab=row_n[1]}
N 5210 -3940 5220 -3950 {lab=rowon_n[1]}
N 5220 -3950 5420 -3950 {lab=rowon_n[1]}
N 5420 -3950 5430 -3940 {lab=rowon_n[1]}
N 5430 -3940 5550 -3940 {lab=rowon_n[1]}
N 5210 -3920 5220 -3930 {lab=#net1}
N 5220 -3930 5420 -3930 {lab=#net1}
N 5420 -3930 5430 -3920 {lab=#net1}
N 5430 -3920 5550 -3920 {lab=#net1}
N 5210 -3900 5220 -3910 {lab=#net2}
N 5220 -3910 5420 -3910 {lab=#net2}
N 5420 -3910 5440 -3900 {lab=#net2}
N 5440 -3900 5550 -3900 {lab=#net2}
N 5550 -3980 5560 -3990 {lab=rowoff_n[1]}
N 5560 -3990 5760 -3990 {lab=rowoff_n[1]}
N 5550 -3960 5560 -3970 {lab=row_n[1]}
N 5560 -3970 5760 -3970 {lab=row_n[1]}
N 5760 -3970 5770 -3960 {lab=row_n[1]}
N 5760 -3990 5770 -3980 {lab=rowoff_n[1]}
N 5550 -3940 5560 -3950 {lab=rowon_n[1]}
N 5560 -3950 5760 -3950 {lab=rowon_n[1]}
N 5550 -3920 5560 -3930 {lab=#net1}
N 5560 -3930 5760 -3930 {lab=#net1}
N 5760 -3930 5770 -3920 {lab=#net1}
N 5550 -3900 5560 -3910 {lab=#net2}
N 5560 -3910 5760 -3910 {lab=#net2}
N 5760 -3910 5770 -3900 {lab=#net2}
N 5760 -3950 5770 -3940 {lab=rowon_n[1]}
N 800 -4150 800 -4140 {
lab=VSS}
N 1120 -4150 1120 -4140 {
lab=VSS}
N 1450 -4150 1450 -4140 {
lab=VSS}
N 1800 -4150 1800 -4140 {
lab=VSS}
N 2150 -4150 2150 -4140 {
lab=VSS}
N 2500 -4150 2500 -4140 {
lab=VSS}
N 2840 -4150 2840 -4140 {
lab=VSS}
N 3190 -4150 3190 -4140 {
lab=VSS}
N 3550 -4150 3550 -4140 {
lab=VSS}
N 3880 -4150 3880 -4140 {
lab=VSS}
N 4210 -4150 4210 -4140 {
lab=VSS}
N 4560 -4150 4560 -4140 {
lab=VSS}
N 4910 -4150 4910 -4140 {
lab=VSS}
N 5250 -4150 5250 -4140 {
lab=VSS}
N 5590 -4150 5590 -4140 {
lab=VSS}
N 5610 -4390 5610 -4370 {
lab=vcm}
N 5590 -4380 5590 -4370 {
lab=VDD}
N 5650 -4390 5650 -4370 {
lab=ctop}
N 4930 -4390 4930 -4370 {
lab=vcm}
N 4910 -4380 4910 -4370 {
lab=VDD}
N 4970 -4390 4970 -4370 {
lab=ctop}
N 5270 -4390 5270 -4370 {
lab=vcm}
N 5250 -4380 5250 -4370 {
lab=VDD}
N 5310 -4390 5310 -4370 {
lab=ctop}
N 4580 -4390 4580 -4370 {
lab=vcm}
N 4560 -4380 4560 -4370 {
lab=VDD}
N 4620 -4390 4620 -4370 {
lab=ctop}
N 4230 -4390 4230 -4370 {
lab=vcm}
N 4210 -4380 4210 -4370 {
lab=VDD}
N 4270 -4390 4270 -4370 {
lab=ctop}
N 3900 -4390 3900 -4370 {
lab=vcm}
N 3880 -4380 3880 -4370 {
lab=VDD}
N 3940 -4390 3940 -4370 {
lab=ctop}
N 3570 -4390 3570 -4370 {
lab=vcm}
N 3550 -4380 3550 -4370 {
lab=VDD}
N 3610 -4390 3610 -4370 {
lab=ctop}
N 3210 -4390 3210 -4370 {
lab=vcm}
N 3190 -4380 3190 -4370 {
lab=VDD}
N 3250 -4390 3250 -4370 {
lab=ctop}
N 2860 -4390 2860 -4370 {
lab=vcm}
N 2840 -4380 2840 -4370 {
lab=VDD}
N 2900 -4390 2900 -4370 {
lab=ctop}
N 2520 -4390 2520 -4370 {
lab=vcm}
N 2500 -4380 2500 -4370 {
lab=VDD}
N 2560 -4390 2560 -4370 {
lab=ctop}
N 2170 -4390 2170 -4370 {
lab=vcm}
N 2150 -4380 2150 -4370 {
lab=VDD}
N 2210 -4390 2210 -4370 {
lab=ctop}
N 1820 -4390 1820 -4370 {
lab=vcm}
N 1800 -4380 1800 -4370 {
lab=VDD}
N 1860 -4390 1860 -4370 {
lab=ctop}
N 1470 -4390 1470 -4370 {
lab=vcm}
N 1450 -4380 1450 -4370 {
lab=VDD}
N 1510 -4390 1510 -4370 {
lab=ctop}
N 1140 -4390 1140 -4370 {
lab=vcm}
N 1120 -4380 1120 -4370 {
lab=VDD}
N 1180 -4390 1180 -4370 {
lab=ctop}
N 820 -4390 820 -4370 {
lab=vcm}
N 800 -4380 800 -4370 {
lab=VDD}
N 860 -4390 860 -4370 {
lab=ctop}
N 740 -4230 760 -4230 {
lab=sample_n}
N 740 -4250 760 -4250 {
lab=sample}
N 740 -4270 760 -4270 {
lab=rowon_n[2]}
N 740 -4290 760 -4290 {
lab=row_n[2]}
N 740 -4310 760 -4310 {
lab=rowoff_n[2]}
N 980 -4250 1080 -4250 {lab=#net3}
N 980 -4230 1080 -4230 {lab=#net4}
N 760 -4310 770 -4320 {lab=rowoff_n[2]}
N 770 -4320 990 -4320 {lab=rowoff_n[2]}
N 990 -4320 1000 -4310 {lab=rowoff_n[2]}
N 1000 -4310 1080 -4310 {lab=rowoff_n[2]}
N 760 -4290 770 -4300 {lab=row_n[2]}
N 770 -4300 990 -4300 {lab=row_n[2]}
N 990 -4300 1000 -4290 {lab=row_n[2]}
N 1000 -4290 1080 -4290 {lab=row_n[2]}
N 760 -4270 770 -4280 {lab=rowon_n[2]}
N 770 -4280 990 -4280 {lab=rowon_n[2]}
N 990 -4280 1000 -4270 {lab=rowon_n[2]}
N 1000 -4270 1080 -4270 {lab=rowon_n[2]}
N 1080 -4310 1090 -4320 {lab=rowoff_n[2]}
N 1080 -4290 1090 -4300 {lab=row_n[2]}
N 1090 -4300 1290 -4300 {lab=row_n[2]}
N 1290 -4300 1300 -4290 {lab=row_n[2]}
N 1300 -4290 1410 -4290 {lab=row_n[2]}
N 1090 -4320 1290 -4320 {lab=rowoff_n[2]}
N 1290 -4320 1300 -4310 {lab=rowoff_n[2]}
N 1300 -4310 1410 -4310 {lab=rowoff_n[2]}
N 1080 -4270 1090 -4280 {lab=rowon_n[2]}
N 1090 -4280 1290 -4280 {lab=rowon_n[2]}
N 1290 -4280 1300 -4270 {lab=rowon_n[2]}
N 1300 -4270 1410 -4270 {lab=rowon_n[2]}
N 1080 -4250 1090 -4260 {lab=#net3}
N 1090 -4260 1290 -4260 {lab=#net3}
N 1290 -4260 1300 -4250 {lab=#net3}
N 1300 -4250 1410 -4250 {lab=#net3}
N 1080 -4230 1090 -4240 {lab=#net4}
N 1090 -4240 1290 -4240 {lab=#net4}
N 1290 -4240 1300 -4230 {lab=#net4}
N 1300 -4230 1410 -4230 {lab=#net4}
N 1410 -4290 1420 -4300 {lab=row_n[2]}
N 1420 -4300 1620 -4300 {lab=row_n[2]}
N 1620 -4300 1630 -4290 {lab=row_n[2]}
N 1630 -4290 1760 -4290 {lab=row_n[2]}
N 1410 -4270 1420 -4280 {lab=rowon_n[2]}
N 1420 -4280 1620 -4280 {lab=rowon_n[2]}
N 1620 -4280 1630 -4270 {lab=rowon_n[2]}
N 1630 -4270 1760 -4270 {lab=rowon_n[2]}
N 1410 -4250 1420 -4260 {lab=#net3}
N 1420 -4260 1620 -4260 {lab=#net3}
N 1620 -4260 1630 -4250 {lab=#net3}
N 1630 -4250 1760 -4250 {lab=#net3}
N 1410 -4230 1430 -4240 {lab=#net4}
N 1430 -4240 1620 -4240 {lab=#net4}
N 1620 -4240 1630 -4230 {lab=#net4}
N 1630 -4230 1760 -4230 {lab=#net4}
N 1410 -4310 1420 -4320 {lab=rowoff_n[2]}
N 1420 -4320 1620 -4320 {lab=rowoff_n[2]}
N 1620 -4320 1630 -4310 {lab=rowoff_n[2]}
N 1630 -4310 1760 -4310 {lab=rowoff_n[2]}
N 1760 -4310 1770 -4320 {lab=rowoff_n[2]}
N 1770 -4320 1970 -4320 {lab=rowoff_n[2]}
N 1970 -4320 1980 -4310 {lab=rowoff_n[2]}
N 1980 -4310 2110 -4310 {lab=rowoff_n[2]}
N 1760 -4290 1770 -4300 {lab=row_n[2]}
N 1770 -4300 1970 -4300 {lab=row_n[2]}
N 1970 -4300 1980 -4290 {lab=row_n[2]}
N 1980 -4290 2110 -4290 {lab=row_n[2]}
N 1760 -4270 1770 -4280 {lab=rowon_n[2]}
N 1770 -4280 1970 -4280 {lab=rowon_n[2]}
N 1970 -4280 1980 -4270 {lab=rowon_n[2]}
N 1980 -4270 2110 -4270 {lab=rowon_n[2]}
N 1760 -4250 1770 -4260 {lab=#net3}
N 1770 -4260 1970 -4260 {lab=#net3}
N 1970 -4260 1980 -4250 {lab=#net3}
N 1980 -4250 2110 -4250 {lab=#net3}
N 1760 -4230 1770 -4240 {lab=#net4}
N 1770 -4240 1970 -4240 {lab=#net4}
N 1970 -4240 1980 -4230 {lab=#net4}
N 1980 -4230 2110 -4230 {lab=#net4}
N 2110 -4310 2120 -4320 {lab=rowoff_n[2]}
N 2120 -4320 2320 -4320 {lab=rowoff_n[2]}
N 2320 -4320 2330 -4310 {lab=rowoff_n[2]}
N 2330 -4310 2460 -4310 {lab=rowoff_n[2]}
N 2110 -4290 2120 -4300 {lab=row_n[2]}
N 2120 -4300 2320 -4300 {lab=row_n[2]}
N 2320 -4300 2330 -4290 {lab=row_n[2]}
N 2330 -4290 2460 -4290 {lab=row_n[2]}
N 2110 -4270 2120 -4280 {lab=rowon_n[2]}
N 2120 -4280 2320 -4280 {lab=rowon_n[2]}
N 2320 -4280 2330 -4270 {lab=rowon_n[2]}
N 2330 -4270 2460 -4270 {lab=rowon_n[2]}
N 2320 -4260 2330 -4250 {lab=#net3}
N 2330 -4250 2460 -4250 {lab=#net3}
N 2110 -4230 2120 -4240 {lab=#net4}
N 2120 -4240 2320 -4240 {lab=#net4}
N 2320 -4240 2330 -4230 {lab=#net4}
N 2330 -4230 2460 -4230 {lab=#net4}
N 2110 -4250 2120 -4260 {lab=#net3}
N 2120 -4260 2320 -4260 {lab=#net3}
N 2460 -4310 2470 -4320 {lab=rowoff_n[2]}
N 2470 -4320 2670 -4320 {lab=rowoff_n[2]}
N 2670 -4320 2680 -4310 {lab=rowoff_n[2]}
N 2680 -4310 2800 -4310 {lab=rowoff_n[2]}
N 2460 -4290 2470 -4300 {lab=row_n[2]}
N 2470 -4300 2670 -4300 {lab=row_n[2]}
N 2670 -4300 2680 -4290 {lab=row_n[2]}
N 2680 -4290 2800 -4290 {lab=row_n[2]}
N 2460 -4270 2470 -4280 {lab=rowon_n[2]}
N 2470 -4280 2670 -4280 {lab=rowon_n[2]}
N 2670 -4280 2680 -4270 {lab=rowon_n[2]}
N 2680 -4270 2800 -4270 {lab=rowon_n[2]}
N 2460 -4250 2470 -4260 {lab=#net3}
N 2470 -4260 2670 -4260 {lab=#net3}
N 2670 -4260 2680 -4250 {lab=#net3}
N 2680 -4250 2800 -4250 {lab=#net3}
N 2460 -4230 2470 -4240 {lab=#net4}
N 2470 -4240 2670 -4240 {lab=#net4}
N 2670 -4240 2680 -4230 {lab=#net4}
N 2680 -4230 2800 -4230 {lab=#net4}
N 2800 -4310 2810 -4320 {lab=rowoff_n[2]}
N 2810 -4320 3010 -4320 {lab=rowoff_n[2]}
N 3010 -4320 3020 -4310 {lab=rowoff_n[2]}
N 3020 -4310 3150 -4310 {lab=rowoff_n[2]}
N 2800 -4290 2810 -4300 {lab=row_n[2]}
N 2810 -4300 3010 -4300 {lab=row_n[2]}
N 3010 -4300 3020 -4290 {lab=row_n[2]}
N 3020 -4290 3150 -4290 {lab=row_n[2]}
N 2800 -4270 2810 -4280 {lab=rowon_n[2]}
N 2810 -4280 3010 -4280 {lab=rowon_n[2]}
N 3010 -4280 3020 -4270 {lab=rowon_n[2]}
N 3020 -4270 3150 -4270 {lab=rowon_n[2]}
N 2800 -4250 2810 -4260 {lab=#net3}
N 2810 -4260 3010 -4260 {lab=#net3}
N 2800 -4230 2810 -4240 {lab=#net4}
N 2810 -4240 3010 -4240 {lab=#net4}
N 3010 -4240 3020 -4230 {lab=#net4}
N 3020 -4230 3150 -4230 {lab=#net4}
N 3010 -4260 3020 -4250 {lab=#net3}
N 3020 -4250 3150 -4250 {lab=#net3}
N 3150 -4310 3160 -4320 {lab=rowoff_n[2]}
N 3160 -4320 3360 -4320 {lab=rowoff_n[2]}
N 3360 -4320 3370 -4310 {lab=rowoff_n[2]}
N 3370 -4310 3510 -4310 {lab=rowoff_n[2]}
N 3150 -4290 3160 -4300 {lab=row_n[2]}
N 3160 -4300 3360 -4300 {lab=row_n[2]}
N 3360 -4300 3370 -4290 {lab=row_n[2]}
N 3370 -4290 3510 -4290 {lab=row_n[2]}
N 3150 -4270 3160 -4280 {lab=rowon_n[2]}
N 3160 -4280 3360 -4280 {lab=rowon_n[2]}
N 3360 -4280 3370 -4270 {lab=rowon_n[2]}
N 3370 -4270 3510 -4270 {lab=rowon_n[2]}
N 3150 -4250 3160 -4260 {lab=#net3}
N 3160 -4260 3360 -4260 {lab=#net3}
N 3360 -4260 3370 -4250 {lab=#net3}
N 3370 -4250 3510 -4250 {lab=#net3}
N 3150 -4230 3160 -4240 {lab=#net4}
N 3160 -4240 3360 -4240 {lab=#net4}
N 3360 -4240 3370 -4230 {lab=#net4}
N 3370 -4230 3510 -4230 {lab=#net4}
N 3510 -4310 3520 -4320 {lab=rowoff_n[2]}
N 3520 -4320 3720 -4320 {lab=rowoff_n[2]}
N 3720 -4320 3730 -4310 {lab=rowoff_n[2]}
N 3730 -4310 3840 -4310 {lab=rowoff_n[2]}
N 3510 -4290 3520 -4300 {lab=row_n[2]}
N 3520 -4300 3720 -4300 {lab=row_n[2]}
N 3720 -4300 3730 -4290 {lab=row_n[2]}
N 3730 -4290 3840 -4290 {lab=row_n[2]}
N 3510 -4270 3520 -4280 {lab=rowon_n[2]}
N 3520 -4280 3720 -4280 {lab=rowon_n[2]}
N 3720 -4280 3730 -4270 {lab=rowon_n[2]}
N 3730 -4270 3840 -4270 {lab=rowon_n[2]}
N 3510 -4250 3520 -4260 {lab=#net3}
N 3520 -4260 3720 -4260 {lab=#net3}
N 3720 -4260 3730 -4250 {lab=#net3}
N 3730 -4250 3840 -4250 {lab=#net3}
N 3510 -4230 3520 -4240 {lab=#net4}
N 3520 -4240 3720 -4240 {lab=#net4}
N 3720 -4240 3730 -4230 {lab=#net4}
N 3730 -4230 3840 -4230 {lab=#net4}
N 3840 -4310 3850 -4320 {lab=rowoff_n[2]}
N 3850 -4320 4050 -4320 {lab=rowoff_n[2]}
N 4050 -4320 4060 -4310 {lab=rowoff_n[2]}
N 4060 -4310 4170 -4310 {lab=rowoff_n[2]}
N 3840 -4290 3850 -4300 {lab=row_n[2]}
N 3850 -4300 4050 -4300 {lab=row_n[2]}
N 4050 -4300 4060 -4290 {lab=row_n[2]}
N 4060 -4290 4170 -4290 {lab=row_n[2]}
N 3840 -4270 3850 -4280 {lab=rowon_n[2]}
N 3850 -4280 4050 -4280 {lab=rowon_n[2]}
N 4050 -4280 4060 -4270 {lab=rowon_n[2]}
N 4060 -4270 4170 -4270 {lab=rowon_n[2]}
N 3840 -4250 3850 -4260 {lab=#net3}
N 3850 -4260 4050 -4260 {lab=#net3}
N 4050 -4260 4060 -4250 {lab=#net3}
N 4060 -4250 4170 -4250 {lab=#net3}
N 3840 -4230 3850 -4240 {lab=#net4}
N 3850 -4240 4050 -4240 {lab=#net4}
N 4050 -4240 4070 -4230 {lab=#net4}
N 4070 -4230 4170 -4230 {lab=#net4}
N 4170 -4310 4180 -4320 {lab=rowoff_n[2]}
N 4180 -4320 4380 -4320 {lab=rowoff_n[2]}
N 4380 -4320 4390 -4310 {lab=rowoff_n[2]}
N 4390 -4310 4520 -4310 {lab=rowoff_n[2]}
N 4170 -4290 4180 -4300 {lab=row_n[2]}
N 4180 -4300 4380 -4300 {lab=row_n[2]}
N 4380 -4300 4390 -4290 {lab=row_n[2]}
N 4390 -4290 4520 -4290 {lab=row_n[2]}
N 4170 -4270 4180 -4280 {lab=rowon_n[2]}
N 4180 -4280 4380 -4280 {lab=rowon_n[2]}
N 4380 -4280 4390 -4270 {lab=rowon_n[2]}
N 4390 -4270 4520 -4270 {lab=rowon_n[2]}
N 4170 -4250 4180 -4260 {lab=#net3}
N 4180 -4260 4380 -4260 {lab=#net3}
N 4380 -4260 4390 -4250 {lab=#net3}
N 4390 -4250 4520 -4250 {lab=#net3}
N 4170 -4230 4180 -4240 {lab=#net4}
N 4180 -4240 4380 -4240 {lab=#net4}
N 4380 -4240 4390 -4230 {lab=#net4}
N 4390 -4230 4520 -4230 {lab=#net4}
N 4520 -4310 4530 -4320 {lab=rowoff_n[2]}
N 4530 -4320 4730 -4320 {lab=rowoff_n[2]}
N 4730 -4320 4740 -4310 {lab=rowoff_n[2]}
N 4740 -4310 4870 -4310 {lab=rowoff_n[2]}
N 4520 -4290 4530 -4300 {lab=row_n[2]}
N 4530 -4300 4730 -4300 {lab=row_n[2]}
N 4520 -4270 4530 -4280 {lab=rowon_n[2]}
N 4530 -4280 4730 -4280 {lab=rowon_n[2]}
N 4730 -4280 4740 -4270 {lab=rowon_n[2]}
N 4740 -4270 4870 -4270 {lab=rowon_n[2]}
N 4730 -4300 4740 -4290 {lab=row_n[2]}
N 4740 -4290 4870 -4290 {lab=row_n[2]}
N 4520 -4250 4530 -4260 {lab=#net3}
N 4530 -4260 4730 -4260 {lab=#net3}
N 4730 -4260 4740 -4250 {lab=#net3}
N 4740 -4250 4870 -4250 {lab=#net3}
N 4520 -4230 4530 -4240 {lab=#net4}
N 4530 -4240 4730 -4240 {lab=#net4}
N 4730 -4240 4740 -4230 {lab=#net4}
N 4740 -4230 4870 -4230 {lab=#net4}
N 4870 -4310 4880 -4320 {lab=rowoff_n[2]}
N 4880 -4320 5080 -4320 {lab=rowoff_n[2]}
N 5080 -4320 5090 -4310 {lab=rowoff_n[2]}
N 5090 -4310 5210 -4310 {lab=rowoff_n[2]}
N 4870 -4290 4880 -4300 {lab=row_n[2]}
N 4880 -4300 5080 -4300 {lab=row_n[2]}
N 5080 -4300 5090 -4290 {lab=row_n[2]}
N 5090 -4290 5210 -4290 {lab=row_n[2]}
N 4870 -4270 4880 -4280 {lab=rowon_n[2]}
N 4880 -4280 5080 -4280 {lab=rowon_n[2]}
N 5080 -4280 5090 -4270 {lab=rowon_n[2]}
N 5090 -4270 5210 -4270 {lab=rowon_n[2]}
N 4870 -4250 4880 -4260 {lab=#net3}
N 4880 -4260 5080 -4260 {lab=#net3}
N 5080 -4260 5090 -4250 {lab=#net3}
N 5090 -4250 5210 -4250 {lab=#net3}
N 4870 -4230 4880 -4240 {lab=#net4}
N 4880 -4240 5080 -4240 {lab=#net4}
N 5080 -4240 5090 -4230 {lab=#net4}
N 5090 -4230 5210 -4230 {lab=#net4}
N 5210 -4310 5220 -4320 {lab=rowoff_n[2]}
N 5220 -4320 5420 -4320 {lab=rowoff_n[2]}
N 5420 -4320 5430 -4310 {lab=rowoff_n[2]}
N 5430 -4310 5550 -4310 {lab=rowoff_n[2]}
N 5210 -4290 5220 -4300 {lab=row_n[2]}
N 5220 -4300 5420 -4300 {lab=row_n[2]}
N 5420 -4300 5430 -4290 {lab=row_n[2]}
N 5430 -4290 5550 -4290 {lab=row_n[2]}
N 5210 -4270 5220 -4280 {lab=rowon_n[2]}
N 5220 -4280 5420 -4280 {lab=rowon_n[2]}
N 5420 -4280 5430 -4270 {lab=rowon_n[2]}
N 5430 -4270 5550 -4270 {lab=rowon_n[2]}
N 5210 -4250 5220 -4260 {lab=#net3}
N 5220 -4260 5420 -4260 {lab=#net3}
N 5420 -4260 5430 -4250 {lab=#net3}
N 5430 -4250 5550 -4250 {lab=#net3}
N 5210 -4230 5220 -4240 {lab=#net4}
N 5220 -4240 5420 -4240 {lab=#net4}
N 5420 -4240 5440 -4230 {lab=#net4}
N 5440 -4230 5550 -4230 {lab=#net4}
N 5550 -4310 5560 -4320 {lab=rowoff_n[2]}
N 5560 -4320 5760 -4320 {lab=rowoff_n[2]}
N 5550 -4290 5560 -4300 {lab=row_n[2]}
N 5560 -4300 5760 -4300 {lab=row_n[2]}
N 5760 -4300 5770 -4290 {lab=row_n[2]}
N 5760 -4320 5770 -4310 {lab=rowoff_n[2]}
N 5550 -4270 5560 -4280 {lab=rowon_n[2]}
N 5560 -4280 5760 -4280 {lab=rowon_n[2]}
N 5550 -4250 5560 -4260 {lab=#net3}
N 5560 -4260 5760 -4260 {lab=#net3}
N 5760 -4260 5770 -4250 {lab=#net3}
N 5550 -4230 5560 -4240 {lab=#net4}
N 5560 -4240 5760 -4240 {lab=#net4}
N 5760 -4240 5770 -4230 {lab=#net4}
N 5760 -4280 5770 -4270 {lab=rowon_n[2]}
N 880 -3820 890 -3830 {lab=VDD}
N 890 -4080 890 -3830 {lab=VDD}
N 880 -4090 890 -4080 {lab=VDD}
N 880 -4150 880 -4090 {lab=VDD}
N 900 -4150 900 -4090 {lab=VSS}
N 900 -4090 910 -4080 {lab=VSS}
N 910 -4080 910 -3830 {lab=VSS}
N 900 -3820 910 -3830 {lab=VSS}
N 1210 -4080 1210 -3830 {lab=col_n[0]}
N 1200 -4090 1210 -4080 {lab=col_n[0]}
N 1200 -4150 1200 -4090 {lab=col_n[0]}
N 1220 -4150 1220 -4090 {lab=col[0]}
N 1220 -4090 1230 -4080 {lab=col[0]}
N 1230 -4080 1230 -3830 {lab=col[0]}
N 1540 -4080 1540 -3830 {lab=col_n[1]}
N 1530 -4090 1540 -4080 {lab=col_n[1]}
N 1530 -4150 1530 -4090 {lab=col_n[1]}
N 1550 -4150 1550 -4090 {lab=col[1]}
N 1550 -4090 1560 -4080 {lab=col[1]}
N 1560 -4080 1560 -3830 {lab=col[1]}
N 1890 -4080 1890 -3830 {lab=col_n[2]}
N 1880 -4090 1890 -4080 {lab=col_n[2]}
N 1880 -4150 1880 -4090 {lab=col_n[2]}
N 1900 -4150 1900 -4090 {lab=col[2]}
N 1900 -4090 1910 -4080 {lab=col[2]}
N 1910 -4080 1910 -3830 {lab=col[2]}
N 2240 -4080 2240 -3830 {lab=col_n[3]}
N 2230 -4090 2240 -4080 {lab=col_n[3]}
N 2230 -4150 2230 -4090 {lab=col_n[3]}
N 2250 -4150 2250 -4090 {lab=col[3]}
N 2250 -4090 2260 -4080 {lab=col[3]}
N 2260 -4080 2260 -3830 {lab=col[3]}
N 2590 -4080 2590 -3830 {lab=col_n[4]}
N 2580 -4090 2590 -4080 {lab=col_n[4]}
N 2580 -4150 2580 -4090 {lab=col_n[4]}
N 2600 -4150 2600 -4090 {lab=col[4]}
N 2600 -4090 2610 -4080 {lab=col[4]}
N 2610 -4080 2610 -3830 {lab=col[4]}
N 2930 -4080 2930 -3830 {lab=col_n[5]}
N 2920 -4090 2930 -4080 {lab=col_n[5]}
N 2920 -4150 2920 -4090 {lab=col_n[5]}
N 2940 -4150 2940 -4090 {lab=col[5]}
N 2940 -4090 2950 -4080 {lab=col[5]}
N 2950 -4080 2950 -3830 {lab=col[5]}
N 3280 -4080 3280 -3830 {lab=col_n[6]}
N 3270 -4090 3280 -4080 {lab=col_n[6]}
N 3270 -4150 3270 -4090 {lab=col_n[6]}
N 3290 -4150 3290 -4090 {lab=col[6]}
N 3290 -4090 3300 -4080 {lab=col[6]}
N 3300 -4080 3300 -3830 {lab=col[6]}
N 3640 -4080 3640 -3830 {lab=col_n[7]}
N 3630 -4090 3640 -4080 {lab=col_n[7]}
N 3630 -4150 3630 -4090 {lab=col_n[7]}
N 3650 -4150 3650 -4090 {lab=col[7]}
N 3650 -4090 3660 -4080 {lab=col[7]}
N 3660 -4080 3660 -3830 {lab=col[7]}
N 3970 -4080 3970 -3830 {lab=col_n[8]}
N 3960 -4090 3970 -4080 {lab=col_n[8]}
N 3960 -4150 3960 -4090 {lab=col_n[8]}
N 3980 -4150 3980 -4090 {lab=col[8]}
N 3980 -4090 3990 -4080 {lab=col[8]}
N 3990 -4080 3990 -3830 {lab=col[8]}
N 4300 -4080 4300 -3830 {lab=col_n[9]}
N 4290 -4090 4300 -4080 {lab=col_n[9]}
N 4290 -4150 4290 -4090 {lab=col_n[9]}
N 4310 -4150 4310 -4090 {lab=col[9]}
N 4310 -4090 4320 -4080 {lab=col[9]}
N 4320 -4080 4320 -3830 {lab=col[9]}
N 4650 -4080 4650 -3830 {lab=col_n[10]}
N 4640 -4090 4650 -4080 {lab=col_n[10]}
N 4640 -4150 4640 -4090 {lab=col_n[10]}
N 4660 -4150 4660 -4090 {lab=col[10]}
N 4660 -4090 4670 -4080 {lab=col[10]}
N 4670 -4080 4670 -3830 {lab=col[10]}
N 5000 -4080 5000 -3830 {lab=col_n[11]}
N 4990 -4090 5000 -4080 {lab=col_n[11]}
N 4990 -4150 4990 -4090 {lab=col_n[11]}
N 5010 -4150 5010 -4090 {lab=col[11]}
N 5010 -4090 5020 -4080 {lab=col[11]}
N 5020 -4080 5020 -3830 {lab=col[11]}
N 5340 -4080 5340 -3830 {lab=col_n[12]}
N 5330 -4090 5340 -4080 {lab=col_n[12]}
N 5330 -4150 5330 -4090 {lab=col_n[12]}
N 5350 -4150 5350 -4090 {lab=col[12]}
N 5350 -4090 5360 -4080 {lab=col[12]}
N 5360 -4080 5360 -3830 {lab=col[12]}
N 5680 -4080 5680 -3830 {lab=VDD}
N 5670 -4090 5680 -4080 {lab=VDD}
N 5670 -4150 5670 -4090 {lab=VDD}
N 5690 -4150 5690 -4090 {lab=VSS}
N 5690 -4090 5700 -4080 {lab=VSS}
N 5700 -4080 5700 -3830 {lab=VSS}
N 5690 -3820 5700 -3830 {lab=VSS}
N 5670 -3820 5680 -3830 {lab=VDD}
N 5330 -3820 5340 -3830 {lab=col_n[12]}
N 5350 -3820 5360 -3830 {lab=col[12]}
N 4990 -3820 5000 -3830 {lab=col_n[11]}
N 5010 -3820 5020 -3830 {lab=col[11]}
N 4640 -3820 4650 -3830 {lab=col_n[10]}
N 4660 -3820 4670 -3830 {lab=col[10]}
N 4310 -3820 4320 -3830 {lab=col[9]}
N 4290 -3820 4300 -3830 {lab=col_n[9]}
N 3980 -3820 3990 -3830 {lab=col[8]}
N 3960 -3820 3970 -3830 {lab=col_n[8]}
N 3630 -3820 3640 -3830 {lab=col_n[7]}
N 3650 -3820 3660 -3830 {lab=col[7]}
N 3270 -3820 3280 -3830 {lab=col_n[6]}
N 3290 -3820 3300 -3830 {lab=col[6]}
N 2940 -3820 2950 -3830 {lab=col[5]}
N 2920 -3820 2930 -3830 {lab=col_n[5]}
N 2600 -3820 2610 -3830 {lab=col[4]}
N 2580 -3820 2590 -3830 {lab=col_n[4]}
N 2250 -3820 2260 -3830 {lab=col[3]}
N 2230 -3820 2240 -3830 {lab=col_n[3]}
N 1900 -3820 1910 -3830 {lab=col[2]}
N 1880 -3820 1890 -3830 {lab=col_n[2]}
N 1550 -3820 1560 -3830 {lab=col[1]}
N 1530 -3820 1540 -3830 {lab=col_n[1]}
N 1200 -3820 1210 -3830 {lab=col_n[0]}
N 1220 -3820 1230 -3830 {lab=col[0]}
N 880 -3780 890 -3770 {lab=VDD}
N 880 -3820 880 -3780 {lab=VDD}
N 900 -3820 900 -3780 {lab=VSS}
N 900 -3780 910 -3770 {lab=VSS}
N 800 -4470 800 -4460 {
lab=VSS}
N 1120 -4470 1120 -4460 {
lab=VSS}
N 1450 -4470 1450 -4460 {
lab=VSS}
N 1800 -4470 1800 -4460 {
lab=VSS}
N 2150 -4470 2150 -4460 {
lab=VSS}
N 2500 -4470 2500 -4460 {
lab=VSS}
N 2840 -4470 2840 -4460 {
lab=VSS}
N 3190 -4470 3190 -4460 {
lab=VSS}
N 3550 -4470 3550 -4460 {
lab=VSS}
N 3880 -4470 3880 -4460 {
lab=VSS}
N 4210 -4470 4210 -4460 {
lab=VSS}
N 4560 -4470 4560 -4460 {
lab=VSS}
N 4910 -4470 4910 -4460 {
lab=VSS}
N 5250 -4470 5250 -4460 {
lab=VSS}
N 5590 -4470 5590 -4460 {
lab=VSS}
N 5610 -4710 5610 -4690 {
lab=vcm}
N 5590 -4700 5590 -4690 {
lab=VDD}
N 5650 -4710 5650 -4690 {
lab=ctop}
N 4930 -4710 4930 -4690 {
lab=vcm}
N 4910 -4700 4910 -4690 {
lab=VDD}
N 4970 -4710 4970 -4690 {
lab=ctop}
N 5270 -4710 5270 -4690 {
lab=vcm}
N 5250 -4700 5250 -4690 {
lab=VDD}
N 5310 -4710 5310 -4690 {
lab=ctop}
N 4580 -4710 4580 -4690 {
lab=vcm}
N 4560 -4700 4560 -4690 {
lab=VDD}
N 4620 -4710 4620 -4690 {
lab=ctop}
N 4230 -4710 4230 -4690 {
lab=vcm}
N 4210 -4700 4210 -4690 {
lab=VDD}
N 4270 -4710 4270 -4690 {
lab=ctop}
N 3900 -4710 3900 -4690 {
lab=vcm}
N 3880 -4700 3880 -4690 {
lab=VDD}
N 3940 -4710 3940 -4690 {
lab=ctop}
N 3570 -4710 3570 -4690 {
lab=vcm}
N 3550 -4700 3550 -4690 {
lab=VDD}
N 3610 -4710 3610 -4690 {
lab=ctop}
N 3210 -4710 3210 -4690 {
lab=vcm}
N 3190 -4700 3190 -4690 {
lab=VDD}
N 3250 -4710 3250 -4690 {
lab=ctop}
N 2860 -4710 2860 -4690 {
lab=vcm}
N 2840 -4700 2840 -4690 {
lab=VDD}
N 2900 -4710 2900 -4690 {
lab=ctop}
N 2520 -4710 2520 -4690 {
lab=vcm}
N 2500 -4700 2500 -4690 {
lab=VDD}
N 2560 -4710 2560 -4690 {
lab=ctop}
N 2170 -4710 2170 -4690 {
lab=vcm}
N 2150 -4700 2150 -4690 {
lab=VDD}
N 2210 -4710 2210 -4690 {
lab=ctop}
N 1820 -4710 1820 -4690 {
lab=vcm}
N 1800 -4700 1800 -4690 {
lab=VDD}
N 1860 -4710 1860 -4690 {
lab=ctop}
N 1470 -4710 1470 -4690 {
lab=vcm}
N 1450 -4700 1450 -4690 {
lab=VDD}
N 1510 -4710 1510 -4690 {
lab=ctop}
N 1140 -4710 1140 -4690 {
lab=vcm}
N 1120 -4700 1120 -4690 {
lab=VDD}
N 1180 -4710 1180 -4690 {
lab=ctop}
N 820 -4710 820 -4690 {
lab=vcm}
N 800 -4700 800 -4690 {
lab=VDD}
N 860 -4710 860 -4690 {
lab=ctop}
N 740 -4550 760 -4550 {
lab=sample_n}
N 740 -4570 760 -4570 {
lab=sample}
N 740 -4590 760 -4590 {
lab=rowon_n[3]}
N 740 -4610 760 -4610 {
lab=row_n[3]}
N 740 -4630 760 -4630 {
lab=rowoff_n[3]}
N 980 -4570 1080 -4570 {lab=#net5}
N 980 -4550 1080 -4550 {lab=#net6}
N 760 -4630 770 -4640 {lab=rowoff_n[3]}
N 770 -4640 990 -4640 {lab=rowoff_n[3]}
N 990 -4640 1000 -4630 {lab=rowoff_n[3]}
N 1000 -4630 1080 -4630 {lab=rowoff_n[3]}
N 760 -4610 770 -4620 {lab=row_n[3]}
N 770 -4620 990 -4620 {lab=row_n[3]}
N 990 -4620 1000 -4610 {lab=row_n[3]}
N 1000 -4610 1080 -4610 {lab=row_n[3]}
N 760 -4590 770 -4600 {lab=rowon_n[3]}
N 770 -4600 990 -4600 {lab=rowon_n[3]}
N 990 -4600 1000 -4590 {lab=rowon_n[3]}
N 1000 -4590 1080 -4590 {lab=rowon_n[3]}
N 1080 -4630 1090 -4640 {lab=rowoff_n[3]}
N 1080 -4610 1090 -4620 {lab=row_n[3]}
N 1090 -4620 1290 -4620 {lab=row_n[3]}
N 1290 -4620 1300 -4610 {lab=row_n[3]}
N 1300 -4610 1410 -4610 {lab=row_n[3]}
N 1090 -4640 1290 -4640 {lab=rowoff_n[3]}
N 1290 -4640 1300 -4630 {lab=rowoff_n[3]}
N 1300 -4630 1410 -4630 {lab=rowoff_n[3]}
N 1080 -4590 1090 -4600 {lab=rowon_n[3]}
N 1090 -4600 1290 -4600 {lab=rowon_n[3]}
N 1290 -4600 1300 -4590 {lab=rowon_n[3]}
N 1300 -4590 1410 -4590 {lab=rowon_n[3]}
N 1080 -4570 1090 -4580 {lab=#net5}
N 1090 -4580 1290 -4580 {lab=#net5}
N 1290 -4580 1300 -4570 {lab=#net5}
N 1300 -4570 1410 -4570 {lab=#net5}
N 1080 -4550 1090 -4560 {lab=#net6}
N 1090 -4560 1290 -4560 {lab=#net6}
N 1290 -4560 1300 -4550 {lab=#net6}
N 1300 -4550 1410 -4550 {lab=#net6}
N 1410 -4610 1420 -4620 {lab=row_n[3]}
N 1420 -4620 1620 -4620 {lab=row_n[3]}
N 1620 -4620 1630 -4610 {lab=row_n[3]}
N 1630 -4610 1760 -4610 {lab=row_n[3]}
N 1410 -4590 1420 -4600 {lab=rowon_n[3]}
N 1420 -4600 1620 -4600 {lab=rowon_n[3]}
N 1620 -4600 1630 -4590 {lab=rowon_n[3]}
N 1630 -4590 1760 -4590 {lab=rowon_n[3]}
N 1410 -4570 1420 -4580 {lab=#net5}
N 1420 -4580 1620 -4580 {lab=#net5}
N 1620 -4580 1630 -4570 {lab=#net5}
N 1630 -4570 1760 -4570 {lab=#net5}
N 1410 -4550 1430 -4560 {lab=#net6}
N 1430 -4560 1620 -4560 {lab=#net6}
N 1620 -4560 1630 -4550 {lab=#net6}
N 1630 -4550 1760 -4550 {lab=#net6}
N 1410 -4630 1420 -4640 {lab=rowoff_n[3]}
N 1420 -4640 1620 -4640 {lab=rowoff_n[3]}
N 1620 -4640 1630 -4630 {lab=rowoff_n[3]}
N 1630 -4630 1760 -4630 {lab=rowoff_n[3]}
N 1760 -4630 1770 -4640 {lab=rowoff_n[3]}
N 1770 -4640 1970 -4640 {lab=rowoff_n[3]}
N 1970 -4640 1980 -4630 {lab=rowoff_n[3]}
N 1980 -4630 2110 -4630 {lab=rowoff_n[3]}
N 1760 -4610 1770 -4620 {lab=row_n[3]}
N 1770 -4620 1970 -4620 {lab=row_n[3]}
N 1970 -4620 1980 -4610 {lab=row_n[3]}
N 1980 -4610 2110 -4610 {lab=row_n[3]}
N 1760 -4590 1770 -4600 {lab=rowon_n[3]}
N 1770 -4600 1970 -4600 {lab=rowon_n[3]}
N 1970 -4600 1980 -4590 {lab=rowon_n[3]}
N 1980 -4590 2110 -4590 {lab=rowon_n[3]}
N 1760 -4570 1770 -4580 {lab=#net5}
N 1770 -4580 1970 -4580 {lab=#net5}
N 1970 -4580 1980 -4570 {lab=#net5}
N 1980 -4570 2110 -4570 {lab=#net5}
N 1760 -4550 1770 -4560 {lab=#net6}
N 1770 -4560 1970 -4560 {lab=#net6}
N 1970 -4560 1980 -4550 {lab=#net6}
N 1980 -4550 2110 -4550 {lab=#net6}
N 2110 -4630 2120 -4640 {lab=rowoff_n[3]}
N 2120 -4640 2320 -4640 {lab=rowoff_n[3]}
N 2320 -4640 2330 -4630 {lab=rowoff_n[3]}
N 2330 -4630 2460 -4630 {lab=rowoff_n[3]}
N 2110 -4610 2120 -4620 {lab=row_n[3]}
N 2120 -4620 2320 -4620 {lab=row_n[3]}
N 2320 -4620 2330 -4610 {lab=row_n[3]}
N 2330 -4610 2460 -4610 {lab=row_n[3]}
N 2110 -4590 2120 -4600 {lab=rowon_n[3]}
N 2120 -4600 2320 -4600 {lab=rowon_n[3]}
N 2320 -4600 2330 -4590 {lab=rowon_n[3]}
N 2330 -4590 2460 -4590 {lab=rowon_n[3]}
N 2320 -4580 2330 -4570 {lab=#net5}
N 2330 -4570 2460 -4570 {lab=#net5}
N 2110 -4550 2120 -4560 {lab=#net6}
N 2120 -4560 2320 -4560 {lab=#net6}
N 2320 -4560 2330 -4550 {lab=#net6}
N 2330 -4550 2460 -4550 {lab=#net6}
N 2110 -4570 2120 -4580 {lab=#net5}
N 2120 -4580 2320 -4580 {lab=#net5}
N 2460 -4630 2470 -4640 {lab=rowoff_n[3]}
N 2470 -4640 2670 -4640 {lab=rowoff_n[3]}
N 2670 -4640 2680 -4630 {lab=rowoff_n[3]}
N 2680 -4630 2800 -4630 {lab=rowoff_n[3]}
N 2460 -4610 2470 -4620 {lab=row_n[3]}
N 2470 -4620 2670 -4620 {lab=row_n[3]}
N 2670 -4620 2680 -4610 {lab=row_n[3]}
N 2680 -4610 2800 -4610 {lab=row_n[3]}
N 2460 -4590 2470 -4600 {lab=rowon_n[3]}
N 2470 -4600 2670 -4600 {lab=rowon_n[3]}
N 2670 -4600 2680 -4590 {lab=rowon_n[3]}
N 2680 -4590 2800 -4590 {lab=rowon_n[3]}
N 2460 -4570 2470 -4580 {lab=#net5}
N 2470 -4580 2670 -4580 {lab=#net5}
N 2670 -4580 2680 -4570 {lab=#net5}
N 2680 -4570 2800 -4570 {lab=#net5}
N 2460 -4550 2470 -4560 {lab=#net6}
N 2470 -4560 2670 -4560 {lab=#net6}
N 2670 -4560 2680 -4550 {lab=#net6}
N 2680 -4550 2800 -4550 {lab=#net6}
N 2800 -4630 2810 -4640 {lab=rowoff_n[3]}
N 2810 -4640 3010 -4640 {lab=rowoff_n[3]}
N 3010 -4640 3020 -4630 {lab=rowoff_n[3]}
N 3020 -4630 3150 -4630 {lab=rowoff_n[3]}
N 2800 -4610 2810 -4620 {lab=row_n[3]}
N 2810 -4620 3010 -4620 {lab=row_n[3]}
N 3010 -4620 3020 -4610 {lab=row_n[3]}
N 3020 -4610 3150 -4610 {lab=row_n[3]}
N 2800 -4590 2810 -4600 {lab=rowon_n[3]}
N 2810 -4600 3010 -4600 {lab=rowon_n[3]}
N 3010 -4600 3020 -4590 {lab=rowon_n[3]}
N 3020 -4590 3150 -4590 {lab=rowon_n[3]}
N 2800 -4570 2810 -4580 {lab=#net5}
N 2810 -4580 3010 -4580 {lab=#net5}
N 2800 -4550 2810 -4560 {lab=#net6}
N 2810 -4560 3010 -4560 {lab=#net6}
N 3010 -4560 3020 -4550 {lab=#net6}
N 3020 -4550 3150 -4550 {lab=#net6}
N 3010 -4580 3020 -4570 {lab=#net5}
N 3020 -4570 3150 -4570 {lab=#net5}
N 3150 -4630 3160 -4640 {lab=rowoff_n[3]}
N 3160 -4640 3360 -4640 {lab=rowoff_n[3]}
N 3360 -4640 3370 -4630 {lab=rowoff_n[3]}
N 3370 -4630 3510 -4630 {lab=rowoff_n[3]}
N 3150 -4610 3160 -4620 {lab=row_n[3]}
N 3160 -4620 3360 -4620 {lab=row_n[3]}
N 3360 -4620 3370 -4610 {lab=row_n[3]}
N 3370 -4610 3510 -4610 {lab=row_n[3]}
N 3150 -4590 3160 -4600 {lab=rowon_n[3]}
N 3160 -4600 3360 -4600 {lab=rowon_n[3]}
N 3360 -4600 3370 -4590 {lab=rowon_n[3]}
N 3370 -4590 3510 -4590 {lab=rowon_n[3]}
N 3150 -4570 3160 -4580 {lab=#net5}
N 3160 -4580 3360 -4580 {lab=#net5}
N 3360 -4580 3370 -4570 {lab=#net5}
N 3370 -4570 3510 -4570 {lab=#net5}
N 3150 -4550 3160 -4560 {lab=#net6}
N 3160 -4560 3360 -4560 {lab=#net6}
N 3360 -4560 3370 -4550 {lab=#net6}
N 3370 -4550 3510 -4550 {lab=#net6}
N 3510 -4630 3520 -4640 {lab=rowoff_n[3]}
N 3520 -4640 3720 -4640 {lab=rowoff_n[3]}
N 3720 -4640 3730 -4630 {lab=rowoff_n[3]}
N 3730 -4630 3840 -4630 {lab=rowoff_n[3]}
N 3510 -4610 3520 -4620 {lab=row_n[3]}
N 3520 -4620 3720 -4620 {lab=row_n[3]}
N 3720 -4620 3730 -4610 {lab=row_n[3]}
N 3730 -4610 3840 -4610 {lab=row_n[3]}
N 3510 -4590 3520 -4600 {lab=rowon_n[3]}
N 3520 -4600 3720 -4600 {lab=rowon_n[3]}
N 3720 -4600 3730 -4590 {lab=rowon_n[3]}
N 3730 -4590 3840 -4590 {lab=rowon_n[3]}
N 3510 -4570 3520 -4580 {lab=#net5}
N 3520 -4580 3720 -4580 {lab=#net5}
N 3720 -4580 3730 -4570 {lab=#net5}
N 3730 -4570 3840 -4570 {lab=#net5}
N 3510 -4550 3520 -4560 {lab=#net6}
N 3520 -4560 3720 -4560 {lab=#net6}
N 3720 -4560 3730 -4550 {lab=#net6}
N 3730 -4550 3840 -4550 {lab=#net6}
N 3840 -4630 3850 -4640 {lab=rowoff_n[3]}
N 3850 -4640 4050 -4640 {lab=rowoff_n[3]}
N 4050 -4640 4060 -4630 {lab=rowoff_n[3]}
N 4060 -4630 4170 -4630 {lab=rowoff_n[3]}
N 3840 -4610 3850 -4620 {lab=row_n[3]}
N 3850 -4620 4050 -4620 {lab=row_n[3]}
N 4050 -4620 4060 -4610 {lab=row_n[3]}
N 4060 -4610 4170 -4610 {lab=row_n[3]}
N 3840 -4590 3850 -4600 {lab=rowon_n[3]}
N 3850 -4600 4050 -4600 {lab=rowon_n[3]}
N 4050 -4600 4060 -4590 {lab=rowon_n[3]}
N 4060 -4590 4170 -4590 {lab=rowon_n[3]}
N 3840 -4570 3850 -4580 {lab=#net5}
N 3850 -4580 4050 -4580 {lab=#net5}
N 4050 -4580 4060 -4570 {lab=#net5}
N 4060 -4570 4170 -4570 {lab=#net5}
N 3840 -4550 3850 -4560 {lab=#net6}
N 3850 -4560 4050 -4560 {lab=#net6}
N 4050 -4560 4070 -4550 {lab=#net6}
N 4070 -4550 4170 -4550 {lab=#net6}
N 4170 -4630 4180 -4640 {lab=rowoff_n[3]}
N 4180 -4640 4380 -4640 {lab=rowoff_n[3]}
N 4380 -4640 4390 -4630 {lab=rowoff_n[3]}
N 4390 -4630 4520 -4630 {lab=rowoff_n[3]}
N 4170 -4610 4180 -4620 {lab=row_n[3]}
N 4180 -4620 4380 -4620 {lab=row_n[3]}
N 4380 -4620 4390 -4610 {lab=row_n[3]}
N 4390 -4610 4520 -4610 {lab=row_n[3]}
N 4170 -4590 4180 -4600 {lab=rowon_n[3]}
N 4180 -4600 4380 -4600 {lab=rowon_n[3]}
N 4380 -4600 4390 -4590 {lab=rowon_n[3]}
N 4390 -4590 4520 -4590 {lab=rowon_n[3]}
N 4170 -4570 4180 -4580 {lab=#net5}
N 4180 -4580 4380 -4580 {lab=#net5}
N 4380 -4580 4390 -4570 {lab=#net5}
N 4390 -4570 4520 -4570 {lab=#net5}
N 4170 -4550 4180 -4560 {lab=#net6}
N 4180 -4560 4380 -4560 {lab=#net6}
N 4380 -4560 4390 -4550 {lab=#net6}
N 4390 -4550 4520 -4550 {lab=#net6}
N 4520 -4630 4530 -4640 {lab=rowoff_n[3]}
N 4530 -4640 4730 -4640 {lab=rowoff_n[3]}
N 4730 -4640 4740 -4630 {lab=rowoff_n[3]}
N 4740 -4630 4870 -4630 {lab=rowoff_n[3]}
N 4520 -4610 4530 -4620 {lab=row_n[3]}
N 4530 -4620 4730 -4620 {lab=row_n[3]}
N 4520 -4590 4530 -4600 {lab=rowon_n[3]}
N 4530 -4600 4730 -4600 {lab=rowon_n[3]}
N 4730 -4600 4740 -4590 {lab=rowon_n[3]}
N 4740 -4590 4870 -4590 {lab=rowon_n[3]}
N 4730 -4620 4740 -4610 {lab=row_n[3]}
N 4740 -4610 4870 -4610 {lab=row_n[3]}
N 4520 -4570 4530 -4580 {lab=#net5}
N 4530 -4580 4730 -4580 {lab=#net5}
N 4730 -4580 4740 -4570 {lab=#net5}
N 4740 -4570 4870 -4570 {lab=#net5}
N 4520 -4550 4530 -4560 {lab=#net6}
N 4530 -4560 4730 -4560 {lab=#net6}
N 4730 -4560 4740 -4550 {lab=#net6}
N 4740 -4550 4870 -4550 {lab=#net6}
N 4870 -4630 4880 -4640 {lab=rowoff_n[3]}
N 4880 -4640 5080 -4640 {lab=rowoff_n[3]}
N 5080 -4640 5090 -4630 {lab=rowoff_n[3]}
N 5090 -4630 5210 -4630 {lab=rowoff_n[3]}
N 4870 -4610 4880 -4620 {lab=row_n[3]}
N 4880 -4620 5080 -4620 {lab=row_n[3]}
N 5080 -4620 5090 -4610 {lab=row_n[3]}
N 5090 -4610 5210 -4610 {lab=row_n[3]}
N 4870 -4590 4880 -4600 {lab=rowon_n[3]}
N 4880 -4600 5080 -4600 {lab=rowon_n[3]}
N 5080 -4600 5090 -4590 {lab=rowon_n[3]}
N 5090 -4590 5210 -4590 {lab=rowon_n[3]}
N 4870 -4570 4880 -4580 {lab=#net5}
N 4880 -4580 5080 -4580 {lab=#net5}
N 5080 -4580 5090 -4570 {lab=#net5}
N 5090 -4570 5210 -4570 {lab=#net5}
N 4870 -4550 4880 -4560 {lab=#net6}
N 4880 -4560 5080 -4560 {lab=#net6}
N 5080 -4560 5090 -4550 {lab=#net6}
N 5090 -4550 5210 -4550 {lab=#net6}
N 5210 -4630 5220 -4640 {lab=rowoff_n[3]}
N 5220 -4640 5420 -4640 {lab=rowoff_n[3]}
N 5420 -4640 5430 -4630 {lab=rowoff_n[3]}
N 5430 -4630 5550 -4630 {lab=rowoff_n[3]}
N 5210 -4610 5220 -4620 {lab=row_n[3]}
N 5220 -4620 5420 -4620 {lab=row_n[3]}
N 5420 -4620 5430 -4610 {lab=row_n[3]}
N 5430 -4610 5550 -4610 {lab=row_n[3]}
N 5210 -4590 5220 -4600 {lab=rowon_n[3]}
N 5220 -4600 5420 -4600 {lab=rowon_n[3]}
N 5420 -4600 5430 -4590 {lab=rowon_n[3]}
N 5430 -4590 5550 -4590 {lab=rowon_n[3]}
N 5210 -4570 5220 -4580 {lab=#net5}
N 5220 -4580 5420 -4580 {lab=#net5}
N 5420 -4580 5430 -4570 {lab=#net5}
N 5430 -4570 5550 -4570 {lab=#net5}
N 5210 -4550 5220 -4560 {lab=#net6}
N 5220 -4560 5420 -4560 {lab=#net6}
N 5420 -4560 5440 -4550 {lab=#net6}
N 5440 -4550 5550 -4550 {lab=#net6}
N 5550 -4630 5560 -4640 {lab=rowoff_n[3]}
N 5560 -4640 5760 -4640 {lab=rowoff_n[3]}
N 5550 -4610 5560 -4620 {lab=row_n[3]}
N 5560 -4620 5760 -4620 {lab=row_n[3]}
N 5760 -4620 5770 -4610 {lab=row_n[3]}
N 5760 -4640 5770 -4630 {lab=rowoff_n[3]}
N 5550 -4590 5560 -4600 {lab=rowon_n[3]}
N 5560 -4600 5760 -4600 {lab=rowon_n[3]}
N 5550 -4570 5560 -4580 {lab=#net5}
N 5560 -4580 5760 -4580 {lab=#net5}
N 5760 -4580 5770 -4570 {lab=#net5}
N 5550 -4550 5560 -4560 {lab=#net6}
N 5560 -4560 5760 -4560 {lab=#net6}
N 5760 -4560 5770 -4550 {lab=#net6}
N 5760 -4600 5770 -4590 {lab=rowon_n[3]}
N 800 -4800 800 -4790 {
lab=VSS}
N 1120 -4800 1120 -4790 {
lab=VSS}
N 1450 -4800 1450 -4790 {
lab=VSS}
N 1800 -4800 1800 -4790 {
lab=VSS}
N 2150 -4800 2150 -4790 {
lab=VSS}
N 2500 -4800 2500 -4790 {
lab=VSS}
N 2840 -4800 2840 -4790 {
lab=VSS}
N 3190 -4800 3190 -4790 {
lab=VSS}
N 3550 -4800 3550 -4790 {
lab=VSS}
N 3880 -4800 3880 -4790 {
lab=VSS}
N 4210 -4800 4210 -4790 {
lab=VSS}
N 4560 -4800 4560 -4790 {
lab=VSS}
N 4910 -4800 4910 -4790 {
lab=VSS}
N 5250 -4800 5250 -4790 {
lab=VSS}
N 5590 -4800 5590 -4790 {
lab=VSS}
N 5610 -5040 5610 -5020 {
lab=vcm}
N 5590 -5030 5590 -5020 {
lab=VDD}
N 5650 -5040 5650 -5020 {
lab=ctop}
N 4930 -5040 4930 -5020 {
lab=vcm}
N 4910 -5030 4910 -5020 {
lab=VDD}
N 4970 -5040 4970 -5020 {
lab=ctop}
N 5270 -5040 5270 -5020 {
lab=vcm}
N 5250 -5030 5250 -5020 {
lab=VDD}
N 5310 -5040 5310 -5020 {
lab=ctop}
N 4580 -5040 4580 -5020 {
lab=vcm}
N 4560 -5030 4560 -5020 {
lab=VDD}
N 4620 -5040 4620 -5020 {
lab=ctop}
N 4230 -5040 4230 -5020 {
lab=vcm}
N 4210 -5030 4210 -5020 {
lab=VDD}
N 4270 -5040 4270 -5020 {
lab=ctop}
N 3900 -5040 3900 -5020 {
lab=vcm}
N 3880 -5030 3880 -5020 {
lab=VDD}
N 3940 -5040 3940 -5020 {
lab=ctop}
N 3570 -5040 3570 -5020 {
lab=vcm}
N 3550 -5030 3550 -5020 {
lab=VDD}
N 3610 -5040 3610 -5020 {
lab=ctop}
N 3210 -5040 3210 -5020 {
lab=vcm}
N 3190 -5030 3190 -5020 {
lab=VDD}
N 3250 -5040 3250 -5020 {
lab=ctop}
N 2860 -5040 2860 -5020 {
lab=vcm}
N 2840 -5030 2840 -5020 {
lab=VDD}
N 2900 -5040 2900 -5020 {
lab=ctop}
N 2520 -5040 2520 -5020 {
lab=vcm}
N 2500 -5030 2500 -5020 {
lab=VDD}
N 2560 -5040 2560 -5020 {
lab=ctop}
N 2170 -5040 2170 -5020 {
lab=vcm}
N 2150 -5030 2150 -5020 {
lab=VDD}
N 2210 -5040 2210 -5020 {
lab=ctop}
N 1820 -5040 1820 -5020 {
lab=vcm}
N 1800 -5030 1800 -5020 {
lab=VDD}
N 1860 -5040 1860 -5020 {
lab=ctop}
N 1470 -5040 1470 -5020 {
lab=vcm}
N 1450 -5030 1450 -5020 {
lab=VDD}
N 1510 -5040 1510 -5020 {
lab=ctop}
N 1140 -5040 1140 -5020 {
lab=vcm}
N 1120 -5030 1120 -5020 {
lab=VDD}
N 1180 -5040 1180 -5020 {
lab=ctop}
N 820 -5040 820 -5020 {
lab=vcm}
N 800 -5030 800 -5020 {
lab=VDD}
N 860 -5040 860 -5020 {
lab=ctop}
N 740 -4880 760 -4880 {
lab=sample_n}
N 740 -4900 760 -4900 {
lab=sample}
N 740 -4920 760 -4920 {
lab=rowon_n[4]}
N 740 -4940 760 -4940 {
lab=row_n[4]}
N 740 -4960 760 -4960 {
lab=rowoff_n[4]}
N 980 -4900 1080 -4900 {lab=#net7}
N 980 -4880 1080 -4880 {lab=#net8}
N 760 -4960 770 -4970 {lab=rowoff_n[4]}
N 770 -4970 990 -4970 {lab=rowoff_n[4]}
N 990 -4970 1000 -4960 {lab=rowoff_n[4]}
N 1000 -4960 1080 -4960 {lab=rowoff_n[4]}
N 760 -4940 770 -4950 {lab=row_n[4]}
N 770 -4950 990 -4950 {lab=row_n[4]}
N 990 -4950 1000 -4940 {lab=row_n[4]}
N 1000 -4940 1080 -4940 {lab=row_n[4]}
N 760 -4920 770 -4930 {lab=rowon_n[4]}
N 770 -4930 990 -4930 {lab=rowon_n[4]}
N 990 -4930 1000 -4920 {lab=rowon_n[4]}
N 1000 -4920 1080 -4920 {lab=rowon_n[4]}
N 1080 -4960 1090 -4970 {lab=rowoff_n[4]}
N 1080 -4940 1090 -4950 {lab=row_n[4]}
N 1090 -4950 1290 -4950 {lab=row_n[4]}
N 1290 -4950 1300 -4940 {lab=row_n[4]}
N 1300 -4940 1410 -4940 {lab=row_n[4]}
N 1090 -4970 1290 -4970 {lab=rowoff_n[4]}
N 1290 -4970 1300 -4960 {lab=rowoff_n[4]}
N 1300 -4960 1410 -4960 {lab=rowoff_n[4]}
N 1080 -4920 1090 -4930 {lab=rowon_n[4]}
N 1090 -4930 1290 -4930 {lab=rowon_n[4]}
N 1290 -4930 1300 -4920 {lab=rowon_n[4]}
N 1300 -4920 1410 -4920 {lab=rowon_n[4]}
N 1080 -4900 1090 -4910 {lab=#net7}
N 1090 -4910 1290 -4910 {lab=#net7}
N 1290 -4910 1300 -4900 {lab=#net7}
N 1300 -4900 1410 -4900 {lab=#net7}
N 1080 -4880 1090 -4890 {lab=#net8}
N 1090 -4890 1290 -4890 {lab=#net8}
N 1290 -4890 1300 -4880 {lab=#net8}
N 1300 -4880 1410 -4880 {lab=#net8}
N 1410 -4940 1420 -4950 {lab=row_n[4]}
N 1420 -4950 1620 -4950 {lab=row_n[4]}
N 1620 -4950 1630 -4940 {lab=row_n[4]}
N 1630 -4940 1760 -4940 {lab=row_n[4]}
N 1410 -4920 1420 -4930 {lab=rowon_n[4]}
N 1420 -4930 1620 -4930 {lab=rowon_n[4]}
N 1620 -4930 1630 -4920 {lab=rowon_n[4]}
N 1630 -4920 1760 -4920 {lab=rowon_n[4]}
N 1410 -4900 1420 -4910 {lab=#net7}
N 1420 -4910 1620 -4910 {lab=#net7}
N 1620 -4910 1630 -4900 {lab=#net7}
N 1630 -4900 1760 -4900 {lab=#net7}
N 1410 -4880 1430 -4890 {lab=#net8}
N 1430 -4890 1620 -4890 {lab=#net8}
N 1620 -4890 1630 -4880 {lab=#net8}
N 1630 -4880 1760 -4880 {lab=#net8}
N 1410 -4960 1420 -4970 {lab=rowoff_n[4]}
N 1420 -4970 1620 -4970 {lab=rowoff_n[4]}
N 1620 -4970 1630 -4960 {lab=rowoff_n[4]}
N 1630 -4960 1760 -4960 {lab=rowoff_n[4]}
N 1760 -4960 1770 -4970 {lab=rowoff_n[4]}
N 1770 -4970 1970 -4970 {lab=rowoff_n[4]}
N 1970 -4970 1980 -4960 {lab=rowoff_n[4]}
N 1980 -4960 2110 -4960 {lab=rowoff_n[4]}
N 1760 -4940 1770 -4950 {lab=row_n[4]}
N 1770 -4950 1970 -4950 {lab=row_n[4]}
N 1970 -4950 1980 -4940 {lab=row_n[4]}
N 1980 -4940 2110 -4940 {lab=row_n[4]}
N 1760 -4920 1770 -4930 {lab=rowon_n[4]}
N 1770 -4930 1970 -4930 {lab=rowon_n[4]}
N 1970 -4930 1980 -4920 {lab=rowon_n[4]}
N 1980 -4920 2110 -4920 {lab=rowon_n[4]}
N 1760 -4900 1770 -4910 {lab=#net7}
N 1770 -4910 1970 -4910 {lab=#net7}
N 1970 -4910 1980 -4900 {lab=#net7}
N 1980 -4900 2110 -4900 {lab=#net7}
N 1760 -4880 1770 -4890 {lab=#net8}
N 1770 -4890 1970 -4890 {lab=#net8}
N 1970 -4890 1980 -4880 {lab=#net8}
N 1980 -4880 2110 -4880 {lab=#net8}
N 2110 -4960 2120 -4970 {lab=rowoff_n[4]}
N 2120 -4970 2320 -4970 {lab=rowoff_n[4]}
N 2320 -4970 2330 -4960 {lab=rowoff_n[4]}
N 2330 -4960 2460 -4960 {lab=rowoff_n[4]}
N 2110 -4940 2120 -4950 {lab=row_n[4]}
N 2120 -4950 2320 -4950 {lab=row_n[4]}
N 2320 -4950 2330 -4940 {lab=row_n[4]}
N 2330 -4940 2460 -4940 {lab=row_n[4]}
N 2110 -4920 2120 -4930 {lab=rowon_n[4]}
N 2120 -4930 2320 -4930 {lab=rowon_n[4]}
N 2320 -4930 2330 -4920 {lab=rowon_n[4]}
N 2330 -4920 2460 -4920 {lab=rowon_n[4]}
N 2320 -4910 2330 -4900 {lab=#net7}
N 2330 -4900 2460 -4900 {lab=#net7}
N 2110 -4880 2120 -4890 {lab=#net8}
N 2120 -4890 2320 -4890 {lab=#net8}
N 2320 -4890 2330 -4880 {lab=#net8}
N 2330 -4880 2460 -4880 {lab=#net8}
N 2110 -4900 2120 -4910 {lab=#net7}
N 2120 -4910 2320 -4910 {lab=#net7}
N 2460 -4960 2470 -4970 {lab=rowoff_n[4]}
N 2470 -4970 2670 -4970 {lab=rowoff_n[4]}
N 2670 -4970 2680 -4960 {lab=rowoff_n[4]}
N 2680 -4960 2800 -4960 {lab=rowoff_n[4]}
N 2460 -4940 2470 -4950 {lab=row_n[4]}
N 2470 -4950 2670 -4950 {lab=row_n[4]}
N 2670 -4950 2680 -4940 {lab=row_n[4]}
N 2680 -4940 2800 -4940 {lab=row_n[4]}
N 2460 -4920 2470 -4930 {lab=rowon_n[4]}
N 2470 -4930 2670 -4930 {lab=rowon_n[4]}
N 2670 -4930 2680 -4920 {lab=rowon_n[4]}
N 2680 -4920 2800 -4920 {lab=rowon_n[4]}
N 2460 -4900 2470 -4910 {lab=#net7}
N 2470 -4910 2670 -4910 {lab=#net7}
N 2670 -4910 2680 -4900 {lab=#net7}
N 2680 -4900 2800 -4900 {lab=#net7}
N 2460 -4880 2470 -4890 {lab=#net8}
N 2470 -4890 2670 -4890 {lab=#net8}
N 2670 -4890 2680 -4880 {lab=#net8}
N 2680 -4880 2800 -4880 {lab=#net8}
N 2800 -4960 2810 -4970 {lab=rowoff_n[4]}
N 2810 -4970 3010 -4970 {lab=rowoff_n[4]}
N 3010 -4970 3020 -4960 {lab=rowoff_n[4]}
N 3020 -4960 3150 -4960 {lab=rowoff_n[4]}
N 2800 -4940 2810 -4950 {lab=row_n[4]}
N 2810 -4950 3010 -4950 {lab=row_n[4]}
N 3010 -4950 3020 -4940 {lab=row_n[4]}
N 3020 -4940 3150 -4940 {lab=row_n[4]}
N 2800 -4920 2810 -4930 {lab=rowon_n[4]}
N 2810 -4930 3010 -4930 {lab=rowon_n[4]}
N 3010 -4930 3020 -4920 {lab=rowon_n[4]}
N 3020 -4920 3150 -4920 {lab=rowon_n[4]}
N 2800 -4900 2810 -4910 {lab=#net7}
N 2810 -4910 3010 -4910 {lab=#net7}
N 2800 -4880 2810 -4890 {lab=#net8}
N 2810 -4890 3010 -4890 {lab=#net8}
N 3010 -4890 3020 -4880 {lab=#net8}
N 3020 -4880 3150 -4880 {lab=#net8}
N 3010 -4910 3020 -4900 {lab=#net7}
N 3020 -4900 3150 -4900 {lab=#net7}
N 3150 -4960 3160 -4970 {lab=rowoff_n[4]}
N 3160 -4970 3360 -4970 {lab=rowoff_n[4]}
N 3360 -4970 3370 -4960 {lab=rowoff_n[4]}
N 3370 -4960 3510 -4960 {lab=rowoff_n[4]}
N 3150 -4940 3160 -4950 {lab=row_n[4]}
N 3160 -4950 3360 -4950 {lab=row_n[4]}
N 3360 -4950 3370 -4940 {lab=row_n[4]}
N 3370 -4940 3510 -4940 {lab=row_n[4]}
N 3150 -4920 3160 -4930 {lab=rowon_n[4]}
N 3160 -4930 3360 -4930 {lab=rowon_n[4]}
N 3360 -4930 3370 -4920 {lab=rowon_n[4]}
N 3370 -4920 3510 -4920 {lab=rowon_n[4]}
N 3150 -4900 3160 -4910 {lab=#net7}
N 3160 -4910 3360 -4910 {lab=#net7}
N 3360 -4910 3370 -4900 {lab=#net7}
N 3370 -4900 3510 -4900 {lab=#net7}
N 3150 -4880 3160 -4890 {lab=#net8}
N 3160 -4890 3360 -4890 {lab=#net8}
N 3360 -4890 3370 -4880 {lab=#net8}
N 3370 -4880 3510 -4880 {lab=#net8}
N 3510 -4960 3520 -4970 {lab=rowoff_n[4]}
N 3520 -4970 3720 -4970 {lab=rowoff_n[4]}
N 3720 -4970 3730 -4960 {lab=rowoff_n[4]}
N 3730 -4960 3840 -4960 {lab=rowoff_n[4]}
N 3510 -4940 3520 -4950 {lab=row_n[4]}
N 3520 -4950 3720 -4950 {lab=row_n[4]}
N 3720 -4950 3730 -4940 {lab=row_n[4]}
N 3730 -4940 3840 -4940 {lab=row_n[4]}
N 3510 -4920 3520 -4930 {lab=rowon_n[4]}
N 3520 -4930 3720 -4930 {lab=rowon_n[4]}
N 3720 -4930 3730 -4920 {lab=rowon_n[4]}
N 3730 -4920 3840 -4920 {lab=rowon_n[4]}
N 3510 -4900 3520 -4910 {lab=#net7}
N 3520 -4910 3720 -4910 {lab=#net7}
N 3720 -4910 3730 -4900 {lab=#net7}
N 3730 -4900 3840 -4900 {lab=#net7}
N 3510 -4880 3520 -4890 {lab=#net8}
N 3520 -4890 3720 -4890 {lab=#net8}
N 3720 -4890 3730 -4880 {lab=#net8}
N 3730 -4880 3840 -4880 {lab=#net8}
N 3840 -4960 3850 -4970 {lab=rowoff_n[4]}
N 3850 -4970 4050 -4970 {lab=rowoff_n[4]}
N 4050 -4970 4060 -4960 {lab=rowoff_n[4]}
N 4060 -4960 4170 -4960 {lab=rowoff_n[4]}
N 3840 -4940 3850 -4950 {lab=row_n[4]}
N 3850 -4950 4050 -4950 {lab=row_n[4]}
N 4050 -4950 4060 -4940 {lab=row_n[4]}
N 4060 -4940 4170 -4940 {lab=row_n[4]}
N 3840 -4920 3850 -4930 {lab=rowon_n[4]}
N 3850 -4930 4050 -4930 {lab=rowon_n[4]}
N 4050 -4930 4060 -4920 {lab=rowon_n[4]}
N 4060 -4920 4170 -4920 {lab=rowon_n[4]}
N 3840 -4900 3850 -4910 {lab=#net7}
N 3850 -4910 4050 -4910 {lab=#net7}
N 4050 -4910 4060 -4900 {lab=#net7}
N 4060 -4900 4170 -4900 {lab=#net7}
N 3840 -4880 3850 -4890 {lab=#net8}
N 3850 -4890 4050 -4890 {lab=#net8}
N 4050 -4890 4070 -4880 {lab=#net8}
N 4070 -4880 4170 -4880 {lab=#net8}
N 4170 -4960 4180 -4970 {lab=rowoff_n[4]}
N 4180 -4970 4380 -4970 {lab=rowoff_n[4]}
N 4380 -4970 4390 -4960 {lab=rowoff_n[4]}
N 4390 -4960 4520 -4960 {lab=rowoff_n[4]}
N 4170 -4940 4180 -4950 {lab=row_n[4]}
N 4180 -4950 4380 -4950 {lab=row_n[4]}
N 4380 -4950 4390 -4940 {lab=row_n[4]}
N 4390 -4940 4520 -4940 {lab=row_n[4]}
N 4170 -4920 4180 -4930 {lab=rowon_n[4]}
N 4180 -4930 4380 -4930 {lab=rowon_n[4]}
N 4380 -4930 4390 -4920 {lab=rowon_n[4]}
N 4390 -4920 4520 -4920 {lab=rowon_n[4]}
N 4170 -4900 4180 -4910 {lab=#net7}
N 4180 -4910 4380 -4910 {lab=#net7}
N 4380 -4910 4390 -4900 {lab=#net7}
N 4390 -4900 4520 -4900 {lab=#net7}
N 4170 -4880 4180 -4890 {lab=#net8}
N 4180 -4890 4380 -4890 {lab=#net8}
N 4380 -4890 4390 -4880 {lab=#net8}
N 4390 -4880 4520 -4880 {lab=#net8}
N 4520 -4960 4530 -4970 {lab=rowoff_n[4]}
N 4530 -4970 4730 -4970 {lab=rowoff_n[4]}
N 4730 -4970 4740 -4960 {lab=rowoff_n[4]}
N 4740 -4960 4870 -4960 {lab=rowoff_n[4]}
N 4520 -4940 4530 -4950 {lab=row_n[4]}
N 4530 -4950 4730 -4950 {lab=row_n[4]}
N 4520 -4920 4530 -4930 {lab=rowon_n[4]}
N 4530 -4930 4730 -4930 {lab=rowon_n[4]}
N 4730 -4930 4740 -4920 {lab=rowon_n[4]}
N 4740 -4920 4870 -4920 {lab=rowon_n[4]}
N 4730 -4950 4740 -4940 {lab=row_n[4]}
N 4740 -4940 4870 -4940 {lab=row_n[4]}
N 4520 -4900 4530 -4910 {lab=#net7}
N 4530 -4910 4730 -4910 {lab=#net7}
N 4730 -4910 4740 -4900 {lab=#net7}
N 4740 -4900 4870 -4900 {lab=#net7}
N 4520 -4880 4530 -4890 {lab=#net8}
N 4530 -4890 4730 -4890 {lab=#net8}
N 4730 -4890 4740 -4880 {lab=#net8}
N 4740 -4880 4870 -4880 {lab=#net8}
N 4870 -4960 4880 -4970 {lab=rowoff_n[4]}
N 4880 -4970 5080 -4970 {lab=rowoff_n[4]}
N 5080 -4970 5090 -4960 {lab=rowoff_n[4]}
N 5090 -4960 5210 -4960 {lab=rowoff_n[4]}
N 4870 -4940 4880 -4950 {lab=row_n[4]}
N 4880 -4950 5080 -4950 {lab=row_n[4]}
N 5080 -4950 5090 -4940 {lab=row_n[4]}
N 5090 -4940 5210 -4940 {lab=row_n[4]}
N 4870 -4920 4880 -4930 {lab=rowon_n[4]}
N 4880 -4930 5080 -4930 {lab=rowon_n[4]}
N 5080 -4930 5090 -4920 {lab=rowon_n[4]}
N 5090 -4920 5210 -4920 {lab=rowon_n[4]}
N 4870 -4900 4880 -4910 {lab=#net7}
N 4880 -4910 5080 -4910 {lab=#net7}
N 5080 -4910 5090 -4900 {lab=#net7}
N 5090 -4900 5210 -4900 {lab=#net7}
N 4870 -4880 4880 -4890 {lab=#net8}
N 4880 -4890 5080 -4890 {lab=#net8}
N 5080 -4890 5090 -4880 {lab=#net8}
N 5090 -4880 5210 -4880 {lab=#net8}
N 5210 -4960 5220 -4970 {lab=rowoff_n[4]}
N 5220 -4970 5420 -4970 {lab=rowoff_n[4]}
N 5420 -4970 5430 -4960 {lab=rowoff_n[4]}
N 5430 -4960 5550 -4960 {lab=rowoff_n[4]}
N 5210 -4940 5220 -4950 {lab=row_n[4]}
N 5220 -4950 5420 -4950 {lab=row_n[4]}
N 5420 -4950 5430 -4940 {lab=row_n[4]}
N 5430 -4940 5550 -4940 {lab=row_n[4]}
N 5210 -4920 5220 -4930 {lab=rowon_n[4]}
N 5220 -4930 5420 -4930 {lab=rowon_n[4]}
N 5420 -4930 5430 -4920 {lab=rowon_n[4]}
N 5430 -4920 5550 -4920 {lab=rowon_n[4]}
N 5210 -4900 5220 -4910 {lab=#net7}
N 5220 -4910 5420 -4910 {lab=#net7}
N 5420 -4910 5430 -4900 {lab=#net7}
N 5430 -4900 5550 -4900 {lab=#net7}
N 5210 -4880 5220 -4890 {lab=#net8}
N 5220 -4890 5420 -4890 {lab=#net8}
N 5420 -4890 5440 -4880 {lab=#net8}
N 5440 -4880 5550 -4880 {lab=#net8}
N 5550 -4960 5560 -4970 {lab=rowoff_n[4]}
N 5560 -4970 5760 -4970 {lab=rowoff_n[4]}
N 5550 -4940 5560 -4950 {lab=row_n[4]}
N 5560 -4950 5760 -4950 {lab=row_n[4]}
N 5760 -4950 5770 -4940 {lab=row_n[4]}
N 5760 -4970 5770 -4960 {lab=rowoff_n[4]}
N 5550 -4920 5560 -4930 {lab=rowon_n[4]}
N 5560 -4930 5760 -4930 {lab=rowon_n[4]}
N 5550 -4900 5560 -4910 {lab=#net7}
N 5560 -4910 5760 -4910 {lab=#net7}
N 5760 -4910 5770 -4900 {lab=#net7}
N 5550 -4880 5560 -4890 {lab=#net8}
N 5560 -4890 5760 -4890 {lab=#net8}
N 5760 -4890 5770 -4880 {lab=#net8}
N 5760 -4930 5770 -4920 {lab=rowon_n[4]}
N 880 -4470 890 -4480 {lab=VDD}
N 890 -4730 890 -4480 {lab=VDD}
N 880 -4740 890 -4730 {lab=VDD}
N 880 -4800 880 -4740 {lab=VDD}
N 900 -4800 900 -4740 {lab=VSS}
N 900 -4740 910 -4730 {lab=VSS}
N 910 -4730 910 -4480 {lab=VSS}
N 900 -4470 910 -4480 {lab=VSS}
N 1210 -4730 1210 -4480 {lab=col_n[0]}
N 1200 -4740 1210 -4730 {lab=col_n[0]}
N 1200 -4800 1200 -4740 {lab=col_n[0]}
N 1220 -4800 1220 -4740 {lab=col[0]}
N 1220 -4740 1230 -4730 {lab=col[0]}
N 1230 -4730 1230 -4480 {lab=col[0]}
N 1540 -4730 1540 -4480 {lab=col_n[1]}
N 1530 -4740 1540 -4730 {lab=col_n[1]}
N 1530 -4800 1530 -4740 {lab=col_n[1]}
N 1550 -4800 1550 -4740 {lab=col[1]}
N 1550 -4740 1560 -4730 {lab=col[1]}
N 1560 -4730 1560 -4480 {lab=col[1]}
N 1890 -4730 1890 -4480 {lab=col_n[2]}
N 1880 -4740 1890 -4730 {lab=col_n[2]}
N 1880 -4800 1880 -4740 {lab=col_n[2]}
N 1900 -4800 1900 -4740 {lab=col[2]}
N 1900 -4740 1910 -4730 {lab=col[2]}
N 1910 -4730 1910 -4480 {lab=col[2]}
N 2240 -4730 2240 -4480 {lab=col_n[3]}
N 2230 -4740 2240 -4730 {lab=col_n[3]}
N 2230 -4800 2230 -4740 {lab=col_n[3]}
N 2250 -4800 2250 -4740 {lab=col[3]}
N 2250 -4740 2260 -4730 {lab=col[3]}
N 2260 -4730 2260 -4480 {lab=col[3]}
N 2590 -4730 2590 -4480 {lab=col_n[4]}
N 2580 -4740 2590 -4730 {lab=col_n[4]}
N 2580 -4800 2580 -4740 {lab=col_n[4]}
N 2600 -4800 2600 -4740 {lab=col[4]}
N 2600 -4740 2610 -4730 {lab=col[4]}
N 2610 -4730 2610 -4480 {lab=col[4]}
N 2930 -4730 2930 -4480 {lab=col_n[5]}
N 2920 -4740 2930 -4730 {lab=col_n[5]}
N 2920 -4800 2920 -4740 {lab=col_n[5]}
N 2940 -4800 2940 -4740 {lab=col[5]}
N 2940 -4740 2950 -4730 {lab=col[5]}
N 2950 -4730 2950 -4480 {lab=col[5]}
N 3280 -4730 3280 -4480 {lab=col_n[6]}
N 3270 -4740 3280 -4730 {lab=col_n[6]}
N 3270 -4800 3270 -4740 {lab=col_n[6]}
N 3290 -4800 3290 -4740 {lab=col[6]}
N 3290 -4740 3300 -4730 {lab=col[6]}
N 3300 -4730 3300 -4480 {lab=col[6]}
N 3640 -4730 3640 -4480 {lab=col_n[7]}
N 3630 -4740 3640 -4730 {lab=col_n[7]}
N 3630 -4800 3630 -4740 {lab=col_n[7]}
N 3650 -4800 3650 -4740 {lab=col[7]}
N 3650 -4740 3660 -4730 {lab=col[7]}
N 3660 -4730 3660 -4480 {lab=col[7]}
N 3970 -4730 3970 -4480 {lab=col_n[8]}
N 3960 -4740 3970 -4730 {lab=col_n[8]}
N 3960 -4800 3960 -4740 {lab=col_n[8]}
N 3980 -4800 3980 -4740 {lab=col[8]}
N 3980 -4740 3990 -4730 {lab=col[8]}
N 3990 -4730 3990 -4480 {lab=col[8]}
N 4300 -4730 4300 -4480 {lab=col_n[9]}
N 4290 -4740 4300 -4730 {lab=col_n[9]}
N 4290 -4800 4290 -4740 {lab=col_n[9]}
N 4310 -4800 4310 -4740 {lab=col[9]}
N 4310 -4740 4320 -4730 {lab=col[9]}
N 4320 -4730 4320 -4480 {lab=col[9]}
N 4650 -4730 4650 -4480 {lab=col_n[10]}
N 4640 -4740 4650 -4730 {lab=col_n[10]}
N 4640 -4800 4640 -4740 {lab=col_n[10]}
N 4660 -4800 4660 -4740 {lab=col[10]}
N 4660 -4740 4670 -4730 {lab=col[10]}
N 4670 -4730 4670 -4480 {lab=col[10]}
N 5000 -4730 5000 -4480 {lab=col_n[11]}
N 4990 -4740 5000 -4730 {lab=col_n[11]}
N 4990 -4800 4990 -4740 {lab=col_n[11]}
N 5010 -4800 5010 -4740 {lab=col[11]}
N 5010 -4740 5020 -4730 {lab=col[11]}
N 5020 -4730 5020 -4480 {lab=col[11]}
N 5340 -4730 5340 -4480 {lab=col_n[12]}
N 5330 -4740 5340 -4730 {lab=col_n[12]}
N 5330 -4800 5330 -4740 {lab=col_n[12]}
N 5350 -4800 5350 -4740 {lab=col[12]}
N 5350 -4740 5360 -4730 {lab=col[12]}
N 5360 -4730 5360 -4480 {lab=col[12]}
N 5680 -4730 5680 -4480 {lab=VDD}
N 5670 -4740 5680 -4730 {lab=VDD}
N 5670 -4800 5670 -4740 {lab=VDD}
N 5690 -4800 5690 -4740 {lab=VSS}
N 5690 -4740 5700 -4730 {lab=VSS}
N 5700 -4730 5700 -4480 {lab=VSS}
N 5690 -4470 5700 -4480 {lab=VSS}
N 5670 -4470 5680 -4480 {lab=VDD}
N 5330 -4470 5340 -4480 {lab=col_n[12]}
N 5350 -4470 5360 -4480 {lab=col[12]}
N 4990 -4470 5000 -4480 {lab=col_n[11]}
N 5010 -4470 5020 -4480 {lab=col[11]}
N 4640 -4470 4650 -4480 {lab=col_n[10]}
N 4660 -4470 4670 -4480 {lab=col[10]}
N 4310 -4470 4320 -4480 {lab=col[9]}
N 4290 -4470 4300 -4480 {lab=col_n[9]}
N 3980 -4470 3990 -4480 {lab=col[8]}
N 3960 -4470 3970 -4480 {lab=col_n[8]}
N 3630 -4470 3640 -4480 {lab=col_n[7]}
N 3650 -4470 3660 -4480 {lab=col[7]}
N 3270 -4470 3280 -4480 {lab=col_n[6]}
N 3290 -4470 3300 -4480 {lab=col[6]}
N 2940 -4470 2950 -4480 {lab=col[5]}
N 2920 -4470 2930 -4480 {lab=col_n[5]}
N 2600 -4470 2610 -4480 {lab=col[4]}
N 2580 -4470 2590 -4480 {lab=col_n[4]}
N 2250 -4470 2260 -4480 {lab=col[3]}
N 2230 -4470 2240 -4480 {lab=col_n[3]}
N 1900 -4470 1910 -4480 {lab=col[2]}
N 1880 -4470 1890 -4480 {lab=col_n[2]}
N 1550 -4470 1560 -4480 {lab=col[1]}
N 1530 -4470 1540 -4480 {lab=col_n[1]}
N 1200 -4470 1210 -4480 {lab=col_n[0]}
N 1220 -4470 1230 -4480 {lab=col[0]}
N 880 -4470 880 -4430 {lab=VDD}
N 900 -4470 900 -4430 {lab=VSS}
N 880 -4150 890 -4160 {lab=VDD}
N 890 -4420 890 -4160 {lab=VDD}
N 880 -4430 890 -4420 {lab=VDD}
N 900 -4430 910 -4420 {lab=VSS}
N 910 -4420 910 -4160 {lab=VSS}
N 900 -4150 910 -4160 {lab=VSS}
N 1200 -4470 1200 -4430 {lab=col_n[0]}
N 1220 -4470 1220 -4430 {lab=col[0]}
N 1210 -4420 1210 -4160 {lab=col_n[0]}
N 1200 -4430 1210 -4420 {lab=col_n[0]}
N 1220 -4430 1230 -4420 {lab=col[0]}
N 1230 -4420 1230 -4160 {lab=col[0]}
N 1530 -4470 1530 -4430 {lab=col_n[1]}
N 1550 -4470 1550 -4430 {lab=col[1]}
N 1540 -4420 1540 -4160 {lab=col_n[1]}
N 1530 -4430 1540 -4420 {lab=col_n[1]}
N 1550 -4430 1560 -4420 {lab=col[1]}
N 1560 -4420 1560 -4160 {lab=col[1]}
N 1880 -4470 1880 -4430 {lab=col_n[2]}
N 1900 -4470 1900 -4430 {lab=col[2]}
N 1890 -4420 1890 -4160 {lab=col_n[2]}
N 1880 -4430 1890 -4420 {lab=col_n[2]}
N 1900 -4430 1910 -4420 {lab=col[2]}
N 1910 -4420 1910 -4160 {lab=col[2]}
N 2230 -4470 2230 -4430 {lab=col_n[3]}
N 2250 -4470 2250 -4430 {lab=col[3]}
N 2240 -4420 2240 -4160 {lab=col_n[3]}
N 2230 -4430 2240 -4420 {lab=col_n[3]}
N 2250 -4430 2260 -4420 {lab=col[3]}
N 2260 -4420 2260 -4160 {lab=col[3]}
N 2580 -4470 2580 -4430 {lab=col_n[4]}
N 2600 -4470 2600 -4430 {lab=col[4]}
N 2590 -4420 2590 -4160 {lab=col_n[4]}
N 2580 -4430 2590 -4420 {lab=col_n[4]}
N 2600 -4430 2610 -4420 {lab=col[4]}
N 2610 -4420 2610 -4160 {lab=col[4]}
N 2920 -4470 2920 -4430 {lab=col_n[5]}
N 2940 -4470 2940 -4430 {lab=col[5]}
N 2930 -4420 2930 -4160 {lab=col_n[5]}
N 2920 -4430 2930 -4420 {lab=col_n[5]}
N 2940 -4430 2950 -4420 {lab=col[5]}
N 2950 -4420 2950 -4160 {lab=col[5]}
N 3270 -4470 3270 -4430 {lab=col_n[6]}
N 3290 -4470 3290 -4430 {lab=col[6]}
N 3280 -4420 3280 -4160 {lab=col_n[6]}
N 3270 -4430 3280 -4420 {lab=col_n[6]}
N 3290 -4430 3300 -4420 {lab=col[6]}
N 3300 -4420 3300 -4160 {lab=col[6]}
N 3630 -4470 3630 -4430 {lab=col_n[7]}
N 3650 -4470 3650 -4430 {lab=col[7]}
N 3640 -4420 3640 -4160 {lab=col_n[7]}
N 3630 -4430 3640 -4420 {lab=col_n[7]}
N 3650 -4430 3660 -4420 {lab=col[7]}
N 3660 -4420 3660 -4160 {lab=col[7]}
N 3960 -4470 3960 -4430 {lab=col_n[8]}
N 3980 -4470 3980 -4430 {lab=col[8]}
N 3970 -4420 3970 -4160 {lab=col_n[8]}
N 3960 -4430 3970 -4420 {lab=col_n[8]}
N 3980 -4430 3990 -4420 {lab=col[8]}
N 3990 -4420 3990 -4160 {lab=col[8]}
N 4640 -4470 4640 -4430 {lab=col_n[10]}
N 4660 -4470 4660 -4430 {lab=col[10]}
N 4650 -4420 4650 -4160 {lab=col_n[10]}
N 4640 -4430 4650 -4420 {lab=col_n[10]}
N 4660 -4430 4670 -4420 {lab=col[10]}
N 4670 -4420 4670 -4160 {lab=col[10]}
N 4990 -4470 4990 -4430 {lab=col_n[11]}
N 5010 -4470 5010 -4430 {lab=col[11]}
N 5000 -4420 5000 -4160 {lab=col_n[11]}
N 4990 -4430 5000 -4420 {lab=col_n[11]}
N 5010 -4430 5020 -4420 {lab=col[11]}
N 5020 -4420 5020 -4160 {lab=col[11]}
N 5330 -4470 5330 -4430 {lab=col_n[12]}
N 5350 -4470 5350 -4430 {lab=col[12]}
N 5340 -4420 5340 -4160 {lab=col_n[12]}
N 5330 -4430 5340 -4420 {lab=col_n[12]}
N 5350 -4430 5360 -4420 {lab=col[12]}
N 5360 -4420 5360 -4160 {lab=col[12]}
N 5670 -4470 5670 -4430 {lab=VDD}
N 5690 -4470 5690 -4430 {lab=VSS}
N 5680 -4420 5680 -4160 {lab=VDD}
N 5670 -4430 5680 -4420 {lab=VDD}
N 5690 -4430 5700 -4420 {lab=VSS}
N 5700 -4420 5700 -4160 {lab=VSS}
N 5690 -4150 5700 -4160 {lab=VSS}
N 5670 -4150 5680 -4160 {lab=VDD}
N 5350 -4150 5360 -4160 {lab=col[12]}
N 5330 -4150 5340 -4160 {lab=col_n[12]}
N 5010 -4150 5020 -4160 {lab=col[11]}
N 4990 -4150 5000 -4160 {lab=col_n[11]}
N 4660 -4150 4670 -4160 {lab=col[10]}
N 4640 -4150 4650 -4160 {lab=col_n[10]}
N 4290 -4470 4290 -4430 {lab=col_n[9]}
N 4310 -4470 4310 -4430 {lab=col[9]}
N 4300 -4420 4300 -4160 {lab=col_n[9]}
N 4290 -4430 4300 -4420 {lab=col_n[9]}
N 4310 -4430 4320 -4420 {lab=col[9]}
N 4320 -4420 4320 -4160 {lab=col[9]}
N 4310 -4150 4320 -4160 {lab=col[9]}
N 4290 -4150 4300 -4160 {lab=col_n[9]}
N 3980 -4150 3990 -4160 {lab=col[8]}
N 3960 -4150 3970 -4160 {lab=col_n[8]}
N 3650 -4150 3660 -4160 {lab=col[7]}
N 3630 -4150 3640 -4160 {lab=col_n[7]}
N 3290 -4150 3300 -4160 {lab=col[6]}
N 3270 -4150 3280 -4160 {lab=col_n[6]}
N 2940 -4150 2950 -4160 {lab=col[5]}
N 2920 -4150 2930 -4160 {lab=col_n[5]}
N 2600 -4150 2610 -4160 {lab=col[4]}
N 2580 -4150 2590 -4160 {lab=col_n[4]}
N 1200 -4150 1210 -4160 {lab=col_n[0]}
N 1220 -4150 1230 -4160 {lab=col[0]}
N 1530 -4150 1540 -4160 {lab=col_n[1]}
N 1550 -4150 1560 -4160 {lab=col[1]}
N 1880 -4150 1890 -4160 {lab=col_n[2]}
N 1900 -4150 1910 -4160 {lab=col[2]}
N 2230 -4150 2240 -4160 {lab=col_n[3]}
N 2250 -4150 2260 -4160 {lab=col[3]}
N 800 -5150 800 -5140 {
lab=VSS}
N 1120 -5150 1120 -5140 {
lab=VSS}
N 1450 -5150 1450 -5140 {
lab=VSS}
N 1800 -5150 1800 -5140 {
lab=VSS}
N 2150 -5150 2150 -5140 {
lab=VSS}
N 2500 -5150 2500 -5140 {
lab=VSS}
N 2840 -5150 2840 -5140 {
lab=VSS}
N 3190 -5150 3190 -5140 {
lab=VSS}
N 3550 -5150 3550 -5140 {
lab=VSS}
N 3880 -5150 3880 -5140 {
lab=VSS}
N 4210 -5150 4210 -5140 {
lab=VSS}
N 4560 -5150 4560 -5140 {
lab=VSS}
N 4910 -5150 4910 -5140 {
lab=VSS}
N 5250 -5150 5250 -5140 {
lab=VSS}
N 5590 -5150 5590 -5140 {
lab=VSS}
N 5610 -5390 5610 -5370 {
lab=vcm}
N 5590 -5380 5590 -5370 {
lab=VDD}
N 5650 -5390 5650 -5370 {
lab=ctop}
N 4930 -5390 4930 -5370 {
lab=vcm}
N 4910 -5380 4910 -5370 {
lab=VDD}
N 4970 -5390 4970 -5370 {
lab=ctop}
N 5270 -5390 5270 -5370 {
lab=vcm}
N 5250 -5380 5250 -5370 {
lab=VDD}
N 5310 -5390 5310 -5370 {
lab=ctop}
N 4580 -5390 4580 -5370 {
lab=vcm}
N 4560 -5380 4560 -5370 {
lab=VDD}
N 4620 -5390 4620 -5370 {
lab=ctop}
N 4230 -5390 4230 -5370 {
lab=vcm}
N 4210 -5380 4210 -5370 {
lab=VDD}
N 4270 -5390 4270 -5370 {
lab=ctop}
N 3900 -5390 3900 -5370 {
lab=vcm}
N 3880 -5380 3880 -5370 {
lab=VDD}
N 3940 -5390 3940 -5370 {
lab=ctop}
N 3570 -5390 3570 -5370 {
lab=vcm}
N 3550 -5380 3550 -5370 {
lab=VDD}
N 3610 -5390 3610 -5370 {
lab=ctop}
N 3210 -5390 3210 -5370 {
lab=vcm}
N 3190 -5380 3190 -5370 {
lab=VDD}
N 3250 -5390 3250 -5370 {
lab=ctop}
N 2860 -5390 2860 -5370 {
lab=vcm}
N 2840 -5380 2840 -5370 {
lab=VDD}
N 2900 -5390 2900 -5370 {
lab=ctop}
N 2520 -5390 2520 -5370 {
lab=vcm}
N 2500 -5380 2500 -5370 {
lab=VDD}
N 2560 -5390 2560 -5370 {
lab=ctop}
N 2170 -5390 2170 -5370 {
lab=vcm}
N 2150 -5380 2150 -5370 {
lab=VDD}
N 2210 -5390 2210 -5370 {
lab=ctop}
N 1820 -5390 1820 -5370 {
lab=vcm}
N 1800 -5380 1800 -5370 {
lab=VDD}
N 1860 -5390 1860 -5370 {
lab=ctop}
N 1470 -5390 1470 -5370 {
lab=vcm}
N 1450 -5380 1450 -5370 {
lab=VDD}
N 1510 -5390 1510 -5370 {
lab=ctop}
N 1140 -5390 1140 -5370 {
lab=vcm}
N 1120 -5380 1120 -5370 {
lab=VDD}
N 1180 -5390 1180 -5370 {
lab=ctop}
N 820 -5390 820 -5370 {
lab=vcm}
N 800 -5380 800 -5370 {
lab=VDD}
N 860 -5390 860 -5370 {
lab=ctop}
N 740 -5230 760 -5230 {
lab=sample_n}
N 740 -5250 760 -5250 {
lab=sample}
N 740 -5270 760 -5270 {
lab=rowon_n[5]}
N 740 -5290 760 -5290 {
lab=row_n[5]}
N 740 -5310 760 -5310 {
lab=rowoff_n[5]}
N 980 -5250 1080 -5250 {lab=#net9}
N 980 -5230 1080 -5230 {lab=#net10}
N 760 -5310 770 -5320 {lab=rowoff_n[5]}
N 770 -5320 990 -5320 {lab=rowoff_n[5]}
N 990 -5320 1000 -5310 {lab=rowoff_n[5]}
N 1000 -5310 1080 -5310 {lab=rowoff_n[5]}
N 760 -5290 770 -5300 {lab=row_n[5]}
N 770 -5300 990 -5300 {lab=row_n[5]}
N 990 -5300 1000 -5290 {lab=row_n[5]}
N 1000 -5290 1080 -5290 {lab=row_n[5]}
N 760 -5270 770 -5280 {lab=rowon_n[5]}
N 770 -5280 990 -5280 {lab=rowon_n[5]}
N 990 -5280 1000 -5270 {lab=rowon_n[5]}
N 1000 -5270 1080 -5270 {lab=rowon_n[5]}
N 1080 -5310 1090 -5320 {lab=rowoff_n[5]}
N 1080 -5290 1090 -5300 {lab=row_n[5]}
N 1090 -5300 1290 -5300 {lab=row_n[5]}
N 1290 -5300 1300 -5290 {lab=row_n[5]}
N 1300 -5290 1410 -5290 {lab=row_n[5]}
N 1090 -5320 1290 -5320 {lab=rowoff_n[5]}
N 1290 -5320 1300 -5310 {lab=rowoff_n[5]}
N 1300 -5310 1410 -5310 {lab=rowoff_n[5]}
N 1080 -5270 1090 -5280 {lab=rowon_n[5]}
N 1090 -5280 1290 -5280 {lab=rowon_n[5]}
N 1290 -5280 1300 -5270 {lab=rowon_n[5]}
N 1300 -5270 1410 -5270 {lab=rowon_n[5]}
N 1080 -5250 1090 -5260 {lab=#net9}
N 1090 -5260 1290 -5260 {lab=#net9}
N 1290 -5260 1300 -5250 {lab=#net9}
N 1300 -5250 1410 -5250 {lab=#net9}
N 1080 -5230 1090 -5240 {lab=#net10}
N 1090 -5240 1290 -5240 {lab=#net10}
N 1290 -5240 1300 -5230 {lab=#net10}
N 1300 -5230 1410 -5230 {lab=#net10}
N 1410 -5290 1420 -5300 {lab=row_n[5]}
N 1420 -5300 1620 -5300 {lab=row_n[5]}
N 1620 -5300 1630 -5290 {lab=row_n[5]}
N 1630 -5290 1760 -5290 {lab=row_n[5]}
N 1410 -5270 1420 -5280 {lab=rowon_n[5]}
N 1420 -5280 1620 -5280 {lab=rowon_n[5]}
N 1620 -5280 1630 -5270 {lab=rowon_n[5]}
N 1630 -5270 1760 -5270 {lab=rowon_n[5]}
N 1410 -5250 1420 -5260 {lab=#net9}
N 1420 -5260 1620 -5260 {lab=#net9}
N 1620 -5260 1630 -5250 {lab=#net9}
N 1630 -5250 1760 -5250 {lab=#net9}
N 1410 -5230 1430 -5240 {lab=#net10}
N 1430 -5240 1620 -5240 {lab=#net10}
N 1620 -5240 1630 -5230 {lab=#net10}
N 1630 -5230 1760 -5230 {lab=#net10}
N 1410 -5310 1420 -5320 {lab=rowoff_n[5]}
N 1420 -5320 1620 -5320 {lab=rowoff_n[5]}
N 1620 -5320 1630 -5310 {lab=rowoff_n[5]}
N 1630 -5310 1760 -5310 {lab=rowoff_n[5]}
N 1760 -5310 1770 -5320 {lab=rowoff_n[5]}
N 1770 -5320 1970 -5320 {lab=rowoff_n[5]}
N 1970 -5320 1980 -5310 {lab=rowoff_n[5]}
N 1980 -5310 2110 -5310 {lab=rowoff_n[5]}
N 1760 -5290 1770 -5300 {lab=row_n[5]}
N 1770 -5300 1970 -5300 {lab=row_n[5]}
N 1970 -5300 1980 -5290 {lab=row_n[5]}
N 1980 -5290 2110 -5290 {lab=row_n[5]}
N 1760 -5270 1770 -5280 {lab=rowon_n[5]}
N 1770 -5280 1970 -5280 {lab=rowon_n[5]}
N 1970 -5280 1980 -5270 {lab=rowon_n[5]}
N 1980 -5270 2110 -5270 {lab=rowon_n[5]}
N 1760 -5250 1770 -5260 {lab=#net9}
N 1770 -5260 1970 -5260 {lab=#net9}
N 1970 -5260 1980 -5250 {lab=#net9}
N 1980 -5250 2110 -5250 {lab=#net9}
N 1760 -5230 1770 -5240 {lab=#net10}
N 1770 -5240 1970 -5240 {lab=#net10}
N 1970 -5240 1980 -5230 {lab=#net10}
N 1980 -5230 2110 -5230 {lab=#net10}
N 2110 -5310 2120 -5320 {lab=rowoff_n[5]}
N 2120 -5320 2320 -5320 {lab=rowoff_n[5]}
N 2320 -5320 2330 -5310 {lab=rowoff_n[5]}
N 2330 -5310 2460 -5310 {lab=rowoff_n[5]}
N 2110 -5290 2120 -5300 {lab=row_n[5]}
N 2120 -5300 2320 -5300 {lab=row_n[5]}
N 2320 -5300 2330 -5290 {lab=row_n[5]}
N 2330 -5290 2460 -5290 {lab=row_n[5]}
N 2110 -5270 2120 -5280 {lab=rowon_n[5]}
N 2120 -5280 2320 -5280 {lab=rowon_n[5]}
N 2320 -5280 2330 -5270 {lab=rowon_n[5]}
N 2330 -5270 2460 -5270 {lab=rowon_n[5]}
N 2320 -5260 2330 -5250 {lab=#net9}
N 2330 -5250 2460 -5250 {lab=#net9}
N 2110 -5230 2120 -5240 {lab=#net10}
N 2120 -5240 2320 -5240 {lab=#net10}
N 2320 -5240 2330 -5230 {lab=#net10}
N 2330 -5230 2460 -5230 {lab=#net10}
N 2110 -5250 2120 -5260 {lab=#net9}
N 2120 -5260 2320 -5260 {lab=#net9}
N 2460 -5310 2470 -5320 {lab=rowoff_n[5]}
N 2470 -5320 2670 -5320 {lab=rowoff_n[5]}
N 2670 -5320 2680 -5310 {lab=rowoff_n[5]}
N 2680 -5310 2800 -5310 {lab=rowoff_n[5]}
N 2460 -5290 2470 -5300 {lab=row_n[5]}
N 2470 -5300 2670 -5300 {lab=row_n[5]}
N 2670 -5300 2680 -5290 {lab=row_n[5]}
N 2680 -5290 2800 -5290 {lab=row_n[5]}
N 2460 -5270 2470 -5280 {lab=rowon_n[5]}
N 2470 -5280 2670 -5280 {lab=rowon_n[5]}
N 2670 -5280 2680 -5270 {lab=rowon_n[5]}
N 2680 -5270 2800 -5270 {lab=rowon_n[5]}
N 2460 -5250 2470 -5260 {lab=#net9}
N 2470 -5260 2670 -5260 {lab=#net9}
N 2670 -5260 2680 -5250 {lab=#net9}
N 2680 -5250 2800 -5250 {lab=#net9}
N 2460 -5230 2470 -5240 {lab=#net10}
N 2470 -5240 2670 -5240 {lab=#net10}
N 2670 -5240 2680 -5230 {lab=#net10}
N 2680 -5230 2800 -5230 {lab=#net10}
N 2800 -5310 2810 -5320 {lab=rowoff_n[5]}
N 2810 -5320 3010 -5320 {lab=rowoff_n[5]}
N 3010 -5320 3020 -5310 {lab=rowoff_n[5]}
N 3020 -5310 3150 -5310 {lab=rowoff_n[5]}
N 2800 -5290 2810 -5300 {lab=row_n[5]}
N 2810 -5300 3010 -5300 {lab=row_n[5]}
N 3010 -5300 3020 -5290 {lab=row_n[5]}
N 3020 -5290 3150 -5290 {lab=row_n[5]}
N 2800 -5270 2810 -5280 {lab=rowon_n[5]}
N 2810 -5280 3010 -5280 {lab=rowon_n[5]}
N 3010 -5280 3020 -5270 {lab=rowon_n[5]}
N 3020 -5270 3150 -5270 {lab=rowon_n[5]}
N 2800 -5250 2810 -5260 {lab=#net9}
N 2810 -5260 3010 -5260 {lab=#net9}
N 2800 -5230 2810 -5240 {lab=#net10}
N 2810 -5240 3010 -5240 {lab=#net10}
N 3010 -5240 3020 -5230 {lab=#net10}
N 3020 -5230 3150 -5230 {lab=#net10}
N 3010 -5260 3020 -5250 {lab=#net9}
N 3020 -5250 3150 -5250 {lab=#net9}
N 3150 -5310 3160 -5320 {lab=rowoff_n[5]}
N 3160 -5320 3360 -5320 {lab=rowoff_n[5]}
N 3360 -5320 3370 -5310 {lab=rowoff_n[5]}
N 3370 -5310 3510 -5310 {lab=rowoff_n[5]}
N 3150 -5290 3160 -5300 {lab=row_n[5]}
N 3160 -5300 3360 -5300 {lab=row_n[5]}
N 3360 -5300 3370 -5290 {lab=row_n[5]}
N 3370 -5290 3510 -5290 {lab=row_n[5]}
N 3150 -5270 3160 -5280 {lab=rowon_n[5]}
N 3160 -5280 3360 -5280 {lab=rowon_n[5]}
N 3360 -5280 3370 -5270 {lab=rowon_n[5]}
N 3370 -5270 3510 -5270 {lab=rowon_n[5]}
N 3150 -5250 3160 -5260 {lab=#net9}
N 3160 -5260 3360 -5260 {lab=#net9}
N 3360 -5260 3370 -5250 {lab=#net9}
N 3370 -5250 3510 -5250 {lab=#net9}
N 3150 -5230 3160 -5240 {lab=#net10}
N 3160 -5240 3360 -5240 {lab=#net10}
N 3360 -5240 3370 -5230 {lab=#net10}
N 3370 -5230 3510 -5230 {lab=#net10}
N 3510 -5310 3520 -5320 {lab=rowoff_n[5]}
N 3520 -5320 3720 -5320 {lab=rowoff_n[5]}
N 3720 -5320 3730 -5310 {lab=rowoff_n[5]}
N 3730 -5310 3840 -5310 {lab=rowoff_n[5]}
N 3510 -5290 3520 -5300 {lab=row_n[5]}
N 3520 -5300 3720 -5300 {lab=row_n[5]}
N 3720 -5300 3730 -5290 {lab=row_n[5]}
N 3730 -5290 3840 -5290 {lab=row_n[5]}
N 3510 -5270 3520 -5280 {lab=rowon_n[5]}
N 3520 -5280 3720 -5280 {lab=rowon_n[5]}
N 3720 -5280 3730 -5270 {lab=rowon_n[5]}
N 3730 -5270 3840 -5270 {lab=rowon_n[5]}
N 3510 -5250 3520 -5260 {lab=#net9}
N 3520 -5260 3720 -5260 {lab=#net9}
N 3720 -5260 3730 -5250 {lab=#net9}
N 3730 -5250 3840 -5250 {lab=#net9}
N 3510 -5230 3520 -5240 {lab=#net10}
N 3520 -5240 3720 -5240 {lab=#net10}
N 3720 -5240 3730 -5230 {lab=#net10}
N 3730 -5230 3840 -5230 {lab=#net10}
N 3840 -5310 3850 -5320 {lab=rowoff_n[5]}
N 3850 -5320 4050 -5320 {lab=rowoff_n[5]}
N 4050 -5320 4060 -5310 {lab=rowoff_n[5]}
N 4060 -5310 4170 -5310 {lab=rowoff_n[5]}
N 3840 -5290 3850 -5300 {lab=row_n[5]}
N 3850 -5300 4050 -5300 {lab=row_n[5]}
N 4050 -5300 4060 -5290 {lab=row_n[5]}
N 4060 -5290 4170 -5290 {lab=row_n[5]}
N 3840 -5270 3850 -5280 {lab=rowon_n[5]}
N 3850 -5280 4050 -5280 {lab=rowon_n[5]}
N 4050 -5280 4060 -5270 {lab=rowon_n[5]}
N 4060 -5270 4170 -5270 {lab=rowon_n[5]}
N 3840 -5250 3850 -5260 {lab=#net9}
N 3850 -5260 4050 -5260 {lab=#net9}
N 4050 -5260 4060 -5250 {lab=#net9}
N 4060 -5250 4170 -5250 {lab=#net9}
N 3840 -5230 3850 -5240 {lab=#net10}
N 3850 -5240 4050 -5240 {lab=#net10}
N 4050 -5240 4070 -5230 {lab=#net10}
N 4070 -5230 4170 -5230 {lab=#net10}
N 4170 -5310 4180 -5320 {lab=rowoff_n[5]}
N 4180 -5320 4380 -5320 {lab=rowoff_n[5]}
N 4380 -5320 4390 -5310 {lab=rowoff_n[5]}
N 4390 -5310 4520 -5310 {lab=rowoff_n[5]}
N 4170 -5290 4180 -5300 {lab=row_n[5]}
N 4180 -5300 4380 -5300 {lab=row_n[5]}
N 4380 -5300 4390 -5290 {lab=row_n[5]}
N 4390 -5290 4520 -5290 {lab=row_n[5]}
N 4170 -5270 4180 -5280 {lab=rowon_n[5]}
N 4180 -5280 4380 -5280 {lab=rowon_n[5]}
N 4380 -5280 4390 -5270 {lab=rowon_n[5]}
N 4390 -5270 4520 -5270 {lab=rowon_n[5]}
N 4170 -5250 4180 -5260 {lab=#net9}
N 4180 -5260 4380 -5260 {lab=#net9}
N 4380 -5260 4390 -5250 {lab=#net9}
N 4390 -5250 4520 -5250 {lab=#net9}
N 4170 -5230 4180 -5240 {lab=#net10}
N 4180 -5240 4380 -5240 {lab=#net10}
N 4380 -5240 4390 -5230 {lab=#net10}
N 4390 -5230 4520 -5230 {lab=#net10}
N 4520 -5310 4530 -5320 {lab=rowoff_n[5]}
N 4530 -5320 4730 -5320 {lab=rowoff_n[5]}
N 4730 -5320 4740 -5310 {lab=rowoff_n[5]}
N 4740 -5310 4870 -5310 {lab=rowoff_n[5]}
N 4520 -5290 4530 -5300 {lab=row_n[5]}
N 4530 -5300 4730 -5300 {lab=row_n[5]}
N 4520 -5270 4530 -5280 {lab=rowon_n[5]}
N 4530 -5280 4730 -5280 {lab=rowon_n[5]}
N 4730 -5280 4740 -5270 {lab=rowon_n[5]}
N 4740 -5270 4870 -5270 {lab=rowon_n[5]}
N 4730 -5300 4740 -5290 {lab=row_n[5]}
N 4740 -5290 4870 -5290 {lab=row_n[5]}
N 4520 -5250 4530 -5260 {lab=#net9}
N 4530 -5260 4730 -5260 {lab=#net9}
N 4730 -5260 4740 -5250 {lab=#net9}
N 4740 -5250 4870 -5250 {lab=#net9}
N 4520 -5230 4530 -5240 {lab=#net10}
N 4530 -5240 4730 -5240 {lab=#net10}
N 4730 -5240 4740 -5230 {lab=#net10}
N 4740 -5230 4870 -5230 {lab=#net10}
N 4870 -5310 4880 -5320 {lab=rowoff_n[5]}
N 4880 -5320 5080 -5320 {lab=rowoff_n[5]}
N 5080 -5320 5090 -5310 {lab=rowoff_n[5]}
N 5090 -5310 5210 -5310 {lab=rowoff_n[5]}
N 4870 -5290 4880 -5300 {lab=row_n[5]}
N 4880 -5300 5080 -5300 {lab=row_n[5]}
N 5080 -5300 5090 -5290 {lab=row_n[5]}
N 5090 -5290 5210 -5290 {lab=row_n[5]}
N 4870 -5270 4880 -5280 {lab=rowon_n[5]}
N 4880 -5280 5080 -5280 {lab=rowon_n[5]}
N 5080 -5280 5090 -5270 {lab=rowon_n[5]}
N 5090 -5270 5210 -5270 {lab=rowon_n[5]}
N 4870 -5250 4880 -5260 {lab=#net9}
N 4880 -5260 5080 -5260 {lab=#net9}
N 5080 -5260 5090 -5250 {lab=#net9}
N 5090 -5250 5210 -5250 {lab=#net9}
N 4870 -5230 4880 -5240 {lab=#net10}
N 4880 -5240 5080 -5240 {lab=#net10}
N 5080 -5240 5090 -5230 {lab=#net10}
N 5090 -5230 5210 -5230 {lab=#net10}
N 5210 -5310 5220 -5320 {lab=rowoff_n[5]}
N 5220 -5320 5420 -5320 {lab=rowoff_n[5]}
N 5420 -5320 5430 -5310 {lab=rowoff_n[5]}
N 5430 -5310 5550 -5310 {lab=rowoff_n[5]}
N 5210 -5290 5220 -5300 {lab=row_n[5]}
N 5220 -5300 5420 -5300 {lab=row_n[5]}
N 5420 -5300 5430 -5290 {lab=row_n[5]}
N 5430 -5290 5550 -5290 {lab=row_n[5]}
N 5210 -5270 5220 -5280 {lab=rowon_n[5]}
N 5220 -5280 5420 -5280 {lab=rowon_n[5]}
N 5420 -5280 5430 -5270 {lab=rowon_n[5]}
N 5430 -5270 5550 -5270 {lab=rowon_n[5]}
N 5210 -5250 5220 -5260 {lab=#net9}
N 5220 -5260 5420 -5260 {lab=#net9}
N 5420 -5260 5430 -5250 {lab=#net9}
N 5430 -5250 5550 -5250 {lab=#net9}
N 5210 -5230 5220 -5240 {lab=#net10}
N 5220 -5240 5420 -5240 {lab=#net10}
N 5420 -5240 5440 -5230 {lab=#net10}
N 5440 -5230 5550 -5230 {lab=#net10}
N 5550 -5310 5560 -5320 {lab=rowoff_n[5]}
N 5560 -5320 5760 -5320 {lab=rowoff_n[5]}
N 5550 -5290 5560 -5300 {lab=row_n[5]}
N 5560 -5300 5760 -5300 {lab=row_n[5]}
N 5760 -5300 5770 -5290 {lab=row_n[5]}
N 5760 -5320 5770 -5310 {lab=rowoff_n[5]}
N 5550 -5270 5560 -5280 {lab=rowon_n[5]}
N 5560 -5280 5760 -5280 {lab=rowon_n[5]}
N 5550 -5250 5560 -5260 {lab=#net9}
N 5560 -5260 5760 -5260 {lab=#net9}
N 5760 -5260 5770 -5250 {lab=#net9}
N 5550 -5230 5560 -5240 {lab=#net10}
N 5560 -5240 5760 -5240 {lab=#net10}
N 5760 -5240 5770 -5230 {lab=#net10}
N 5760 -5280 5770 -5270 {lab=rowon_n[5]}
N 800 -5480 800 -5470 {
lab=VSS}
N 1120 -5480 1120 -5470 {
lab=VSS}
N 1450 -5480 1450 -5470 {
lab=VSS}
N 1800 -5480 1800 -5470 {
lab=VSS}
N 2150 -5480 2150 -5470 {
lab=VSS}
N 2500 -5480 2500 -5470 {
lab=VSS}
N 2840 -5480 2840 -5470 {
lab=VSS}
N 3190 -5480 3190 -5470 {
lab=VSS}
N 3550 -5480 3550 -5470 {
lab=VSS}
N 3880 -5480 3880 -5470 {
lab=VSS}
N 4210 -5480 4210 -5470 {
lab=VSS}
N 4560 -5480 4560 -5470 {
lab=VSS}
N 4910 -5480 4910 -5470 {
lab=VSS}
N 5250 -5480 5250 -5470 {
lab=VSS}
N 5590 -5480 5590 -5470 {
lab=VSS}
N 5610 -5720 5610 -5700 {
lab=vcm}
N 5590 -5710 5590 -5700 {
lab=VDD}
N 5650 -5720 5650 -5700 {
lab=ctop}
N 4930 -5720 4930 -5700 {
lab=vcm}
N 4910 -5710 4910 -5700 {
lab=VDD}
N 4970 -5720 4970 -5700 {
lab=ctop}
N 5270 -5720 5270 -5700 {
lab=vcm}
N 5250 -5710 5250 -5700 {
lab=VDD}
N 5310 -5720 5310 -5700 {
lab=ctop}
N 4580 -5720 4580 -5700 {
lab=vcm}
N 4560 -5710 4560 -5700 {
lab=VDD}
N 4620 -5720 4620 -5700 {
lab=ctop}
N 4230 -5720 4230 -5700 {
lab=vcm}
N 4210 -5710 4210 -5700 {
lab=VDD}
N 4270 -5720 4270 -5700 {
lab=ctop}
N 3900 -5720 3900 -5700 {
lab=vcm}
N 3880 -5710 3880 -5700 {
lab=VDD}
N 3940 -5720 3940 -5700 {
lab=ctop}
N 3570 -5720 3570 -5700 {
lab=vcm}
N 3550 -5710 3550 -5700 {
lab=VDD}
N 3610 -5720 3610 -5700 {
lab=ctop}
N 3210 -5720 3210 -5700 {
lab=vcm}
N 3190 -5710 3190 -5700 {
lab=VDD}
N 3250 -5720 3250 -5700 {
lab=ctop}
N 2860 -5720 2860 -5700 {
lab=vcm}
N 2840 -5710 2840 -5700 {
lab=VDD}
N 2900 -5720 2900 -5700 {
lab=ctop}
N 2520 -5720 2520 -5700 {
lab=vcm}
N 2500 -5710 2500 -5700 {
lab=VDD}
N 2560 -5720 2560 -5700 {
lab=ctop}
N 2170 -5720 2170 -5700 {
lab=vcm}
N 2150 -5710 2150 -5700 {
lab=VDD}
N 2210 -5720 2210 -5700 {
lab=ctop}
N 1820 -5720 1820 -5700 {
lab=vcm}
N 1800 -5710 1800 -5700 {
lab=VDD}
N 1860 -5720 1860 -5700 {
lab=ctop}
N 1470 -5720 1470 -5700 {
lab=vcm}
N 1450 -5710 1450 -5700 {
lab=VDD}
N 1510 -5720 1510 -5700 {
lab=ctop}
N 1140 -5720 1140 -5700 {
lab=vcm}
N 1120 -5710 1120 -5700 {
lab=VDD}
N 1180 -5720 1180 -5700 {
lab=ctop}
N 820 -5720 820 -5700 {
lab=vcm}
N 800 -5710 800 -5700 {
lab=VDD}
N 860 -5720 860 -5700 {
lab=ctop}
N 740 -5560 760 -5560 {
lab=sample_n}
N 740 -5580 760 -5580 {
lab=sample}
N 740 -5600 760 -5600 {
lab=rowon_n[6]}
N 740 -5620 760 -5620 {
lab=row_n[6]}
N 740 -5640 760 -5640 {
lab=rowoff_n[6]}
N 980 -5580 1080 -5580 {lab=#net11}
N 980 -5560 1080 -5560 {lab=#net12}
N 760 -5640 770 -5650 {lab=rowoff_n[6]}
N 770 -5650 990 -5650 {lab=rowoff_n[6]}
N 990 -5650 1000 -5640 {lab=rowoff_n[6]}
N 1000 -5640 1080 -5640 {lab=rowoff_n[6]}
N 760 -5620 770 -5630 {lab=row_n[6]}
N 770 -5630 990 -5630 {lab=row_n[6]}
N 990 -5630 1000 -5620 {lab=row_n[6]}
N 1000 -5620 1080 -5620 {lab=row_n[6]}
N 760 -5600 770 -5610 {lab=rowon_n[6]}
N 770 -5610 990 -5610 {lab=rowon_n[6]}
N 990 -5610 1000 -5600 {lab=rowon_n[6]}
N 1000 -5600 1080 -5600 {lab=rowon_n[6]}
N 1080 -5640 1090 -5650 {lab=rowoff_n[6]}
N 1080 -5620 1090 -5630 {lab=row_n[6]}
N 1090 -5630 1290 -5630 {lab=row_n[6]}
N 1290 -5630 1300 -5620 {lab=row_n[6]}
N 1300 -5620 1410 -5620 {lab=row_n[6]}
N 1090 -5650 1290 -5650 {lab=rowoff_n[6]}
N 1290 -5650 1300 -5640 {lab=rowoff_n[6]}
N 1300 -5640 1410 -5640 {lab=rowoff_n[6]}
N 1080 -5600 1090 -5610 {lab=rowon_n[6]}
N 1090 -5610 1290 -5610 {lab=rowon_n[6]}
N 1290 -5610 1300 -5600 {lab=rowon_n[6]}
N 1300 -5600 1410 -5600 {lab=rowon_n[6]}
N 1080 -5580 1090 -5590 {lab=#net11}
N 1090 -5590 1290 -5590 {lab=#net11}
N 1290 -5590 1300 -5580 {lab=#net11}
N 1300 -5580 1410 -5580 {lab=#net11}
N 1080 -5560 1090 -5570 {lab=#net12}
N 1090 -5570 1290 -5570 {lab=#net12}
N 1290 -5570 1300 -5560 {lab=#net12}
N 1300 -5560 1410 -5560 {lab=#net12}
N 1410 -5620 1420 -5630 {lab=row_n[6]}
N 1420 -5630 1620 -5630 {lab=row_n[6]}
N 1620 -5630 1630 -5620 {lab=row_n[6]}
N 1630 -5620 1760 -5620 {lab=row_n[6]}
N 1410 -5600 1420 -5610 {lab=rowon_n[6]}
N 1420 -5610 1620 -5610 {lab=rowon_n[6]}
N 1620 -5610 1630 -5600 {lab=rowon_n[6]}
N 1630 -5600 1760 -5600 {lab=rowon_n[6]}
N 1410 -5580 1420 -5590 {lab=#net11}
N 1420 -5590 1620 -5590 {lab=#net11}
N 1620 -5590 1630 -5580 {lab=#net11}
N 1630 -5580 1760 -5580 {lab=#net11}
N 1410 -5560 1430 -5570 {lab=#net12}
N 1430 -5570 1620 -5570 {lab=#net12}
N 1620 -5570 1630 -5560 {lab=#net12}
N 1630 -5560 1760 -5560 {lab=#net12}
N 1410 -5640 1420 -5650 {lab=rowoff_n[6]}
N 1420 -5650 1620 -5650 {lab=rowoff_n[6]}
N 1620 -5650 1630 -5640 {lab=rowoff_n[6]}
N 1630 -5640 1760 -5640 {lab=rowoff_n[6]}
N 1760 -5640 1770 -5650 {lab=rowoff_n[6]}
N 1770 -5650 1970 -5650 {lab=rowoff_n[6]}
N 1970 -5650 1980 -5640 {lab=rowoff_n[6]}
N 1980 -5640 2110 -5640 {lab=rowoff_n[6]}
N 1760 -5620 1770 -5630 {lab=row_n[6]}
N 1770 -5630 1970 -5630 {lab=row_n[6]}
N 1970 -5630 1980 -5620 {lab=row_n[6]}
N 1980 -5620 2110 -5620 {lab=row_n[6]}
N 1760 -5600 1770 -5610 {lab=rowon_n[6]}
N 1770 -5610 1970 -5610 {lab=rowon_n[6]}
N 1970 -5610 1980 -5600 {lab=rowon_n[6]}
N 1980 -5600 2110 -5600 {lab=rowon_n[6]}
N 1760 -5580 1770 -5590 {lab=#net11}
N 1770 -5590 1970 -5590 {lab=#net11}
N 1970 -5590 1980 -5580 {lab=#net11}
N 1980 -5580 2110 -5580 {lab=#net11}
N 1760 -5560 1770 -5570 {lab=#net12}
N 1770 -5570 1970 -5570 {lab=#net12}
N 1970 -5570 1980 -5560 {lab=#net12}
N 1980 -5560 2110 -5560 {lab=#net12}
N 2110 -5640 2120 -5650 {lab=rowoff_n[6]}
N 2120 -5650 2320 -5650 {lab=rowoff_n[6]}
N 2320 -5650 2330 -5640 {lab=rowoff_n[6]}
N 2330 -5640 2460 -5640 {lab=rowoff_n[6]}
N 2110 -5620 2120 -5630 {lab=row_n[6]}
N 2120 -5630 2320 -5630 {lab=row_n[6]}
N 2320 -5630 2330 -5620 {lab=row_n[6]}
N 2330 -5620 2460 -5620 {lab=row_n[6]}
N 2110 -5600 2120 -5610 {lab=rowon_n[6]}
N 2120 -5610 2320 -5610 {lab=rowon_n[6]}
N 2320 -5610 2330 -5600 {lab=rowon_n[6]}
N 2330 -5600 2460 -5600 {lab=rowon_n[6]}
N 2320 -5590 2330 -5580 {lab=#net11}
N 2330 -5580 2460 -5580 {lab=#net11}
N 2110 -5560 2120 -5570 {lab=#net12}
N 2120 -5570 2320 -5570 {lab=#net12}
N 2320 -5570 2330 -5560 {lab=#net12}
N 2330 -5560 2460 -5560 {lab=#net12}
N 2110 -5580 2120 -5590 {lab=#net11}
N 2120 -5590 2320 -5590 {lab=#net11}
N 2460 -5640 2470 -5650 {lab=rowoff_n[6]}
N 2470 -5650 2670 -5650 {lab=rowoff_n[6]}
N 2670 -5650 2680 -5640 {lab=rowoff_n[6]}
N 2680 -5640 2800 -5640 {lab=rowoff_n[6]}
N 2460 -5620 2470 -5630 {lab=row_n[6]}
N 2470 -5630 2670 -5630 {lab=row_n[6]}
N 2670 -5630 2680 -5620 {lab=row_n[6]}
N 2680 -5620 2800 -5620 {lab=row_n[6]}
N 2460 -5600 2470 -5610 {lab=rowon_n[6]}
N 2470 -5610 2670 -5610 {lab=rowon_n[6]}
N 2670 -5610 2680 -5600 {lab=rowon_n[6]}
N 2680 -5600 2800 -5600 {lab=rowon_n[6]}
N 2460 -5580 2470 -5590 {lab=#net11}
N 2470 -5590 2670 -5590 {lab=#net11}
N 2670 -5590 2680 -5580 {lab=#net11}
N 2680 -5580 2800 -5580 {lab=#net11}
N 2460 -5560 2470 -5570 {lab=#net12}
N 2470 -5570 2670 -5570 {lab=#net12}
N 2670 -5570 2680 -5560 {lab=#net12}
N 2680 -5560 2800 -5560 {lab=#net12}
N 2800 -5640 2810 -5650 {lab=rowoff_n[6]}
N 2810 -5650 3010 -5650 {lab=rowoff_n[6]}
N 3010 -5650 3020 -5640 {lab=rowoff_n[6]}
N 3020 -5640 3150 -5640 {lab=rowoff_n[6]}
N 2800 -5620 2810 -5630 {lab=row_n[6]}
N 2810 -5630 3010 -5630 {lab=row_n[6]}
N 3010 -5630 3020 -5620 {lab=row_n[6]}
N 3020 -5620 3150 -5620 {lab=row_n[6]}
N 2800 -5600 2810 -5610 {lab=rowon_n[6]}
N 2810 -5610 3010 -5610 {lab=rowon_n[6]}
N 3010 -5610 3020 -5600 {lab=rowon_n[6]}
N 3020 -5600 3150 -5600 {lab=rowon_n[6]}
N 2800 -5580 2810 -5590 {lab=#net11}
N 2810 -5590 3010 -5590 {lab=#net11}
N 2800 -5560 2810 -5570 {lab=#net12}
N 2810 -5570 3010 -5570 {lab=#net12}
N 3010 -5570 3020 -5560 {lab=#net12}
N 3020 -5560 3150 -5560 {lab=#net12}
N 3010 -5590 3020 -5580 {lab=#net11}
N 3020 -5580 3150 -5580 {lab=#net11}
N 3150 -5640 3160 -5650 {lab=rowoff_n[6]}
N 3160 -5650 3360 -5650 {lab=rowoff_n[6]}
N 3360 -5650 3370 -5640 {lab=rowoff_n[6]}
N 3370 -5640 3510 -5640 {lab=rowoff_n[6]}
N 3150 -5620 3160 -5630 {lab=row_n[6]}
N 3160 -5630 3360 -5630 {lab=row_n[6]}
N 3360 -5630 3370 -5620 {lab=row_n[6]}
N 3370 -5620 3510 -5620 {lab=row_n[6]}
N 3150 -5600 3160 -5610 {lab=rowon_n[6]}
N 3160 -5610 3360 -5610 {lab=rowon_n[6]}
N 3360 -5610 3370 -5600 {lab=rowon_n[6]}
N 3370 -5600 3510 -5600 {lab=rowon_n[6]}
N 3150 -5580 3160 -5590 {lab=#net11}
N 3160 -5590 3360 -5590 {lab=#net11}
N 3360 -5590 3370 -5580 {lab=#net11}
N 3370 -5580 3510 -5580 {lab=#net11}
N 3150 -5560 3160 -5570 {lab=#net12}
N 3160 -5570 3360 -5570 {lab=#net12}
N 3360 -5570 3370 -5560 {lab=#net12}
N 3370 -5560 3510 -5560 {lab=#net12}
N 3510 -5640 3520 -5650 {lab=rowoff_n[6]}
N 3520 -5650 3720 -5650 {lab=rowoff_n[6]}
N 3720 -5650 3730 -5640 {lab=rowoff_n[6]}
N 3730 -5640 3840 -5640 {lab=rowoff_n[6]}
N 3510 -5620 3520 -5630 {lab=row_n[6]}
N 3520 -5630 3720 -5630 {lab=row_n[6]}
N 3720 -5630 3730 -5620 {lab=row_n[6]}
N 3730 -5620 3840 -5620 {lab=row_n[6]}
N 3510 -5600 3520 -5610 {lab=rowon_n[6]}
N 3520 -5610 3720 -5610 {lab=rowon_n[6]}
N 3720 -5610 3730 -5600 {lab=rowon_n[6]}
N 3730 -5600 3840 -5600 {lab=rowon_n[6]}
N 3510 -5580 3520 -5590 {lab=#net11}
N 3520 -5590 3720 -5590 {lab=#net11}
N 3720 -5590 3730 -5580 {lab=#net11}
N 3730 -5580 3840 -5580 {lab=#net11}
N 3510 -5560 3520 -5570 {lab=#net12}
N 3520 -5570 3720 -5570 {lab=#net12}
N 3720 -5570 3730 -5560 {lab=#net12}
N 3730 -5560 3840 -5560 {lab=#net12}
N 3840 -5640 3850 -5650 {lab=rowoff_n[6]}
N 3850 -5650 4050 -5650 {lab=rowoff_n[6]}
N 4050 -5650 4060 -5640 {lab=rowoff_n[6]}
N 4060 -5640 4170 -5640 {lab=rowoff_n[6]}
N 3840 -5620 3850 -5630 {lab=row_n[6]}
N 3850 -5630 4050 -5630 {lab=row_n[6]}
N 4050 -5630 4060 -5620 {lab=row_n[6]}
N 4060 -5620 4170 -5620 {lab=row_n[6]}
N 3840 -5600 3850 -5610 {lab=rowon_n[6]}
N 3850 -5610 4050 -5610 {lab=rowon_n[6]}
N 4050 -5610 4060 -5600 {lab=rowon_n[6]}
N 4060 -5600 4170 -5600 {lab=rowon_n[6]}
N 3840 -5580 3850 -5590 {lab=#net11}
N 3850 -5590 4050 -5590 {lab=#net11}
N 4050 -5590 4060 -5580 {lab=#net11}
N 4060 -5580 4170 -5580 {lab=#net11}
N 3840 -5560 3850 -5570 {lab=#net12}
N 3850 -5570 4050 -5570 {lab=#net12}
N 4050 -5570 4070 -5560 {lab=#net12}
N 4070 -5560 4170 -5560 {lab=#net12}
N 4170 -5640 4180 -5650 {lab=rowoff_n[6]}
N 4180 -5650 4380 -5650 {lab=rowoff_n[6]}
N 4380 -5650 4390 -5640 {lab=rowoff_n[6]}
N 4390 -5640 4520 -5640 {lab=rowoff_n[6]}
N 4170 -5620 4180 -5630 {lab=row_n[6]}
N 4180 -5630 4380 -5630 {lab=row_n[6]}
N 4380 -5630 4390 -5620 {lab=row_n[6]}
N 4390 -5620 4520 -5620 {lab=row_n[6]}
N 4170 -5600 4180 -5610 {lab=rowon_n[6]}
N 4180 -5610 4380 -5610 {lab=rowon_n[6]}
N 4380 -5610 4390 -5600 {lab=rowon_n[6]}
N 4390 -5600 4520 -5600 {lab=rowon_n[6]}
N 4170 -5580 4180 -5590 {lab=#net11}
N 4180 -5590 4380 -5590 {lab=#net11}
N 4380 -5590 4390 -5580 {lab=#net11}
N 4390 -5580 4520 -5580 {lab=#net11}
N 4170 -5560 4180 -5570 {lab=#net12}
N 4180 -5570 4380 -5570 {lab=#net12}
N 4380 -5570 4390 -5560 {lab=#net12}
N 4390 -5560 4520 -5560 {lab=#net12}
N 4520 -5640 4530 -5650 {lab=rowoff_n[6]}
N 4530 -5650 4730 -5650 {lab=rowoff_n[6]}
N 4730 -5650 4740 -5640 {lab=rowoff_n[6]}
N 4740 -5640 4870 -5640 {lab=rowoff_n[6]}
N 4520 -5620 4530 -5630 {lab=row_n[6]}
N 4530 -5630 4730 -5630 {lab=row_n[6]}
N 4520 -5600 4530 -5610 {lab=rowon_n[6]}
N 4530 -5610 4730 -5610 {lab=rowon_n[6]}
N 4730 -5610 4740 -5600 {lab=rowon_n[6]}
N 4740 -5600 4870 -5600 {lab=rowon_n[6]}
N 4730 -5630 4740 -5620 {lab=row_n[6]}
N 4740 -5620 4870 -5620 {lab=row_n[6]}
N 4520 -5580 4530 -5590 {lab=#net11}
N 4530 -5590 4730 -5590 {lab=#net11}
N 4730 -5590 4740 -5580 {lab=#net11}
N 4740 -5580 4870 -5580 {lab=#net11}
N 4520 -5560 4530 -5570 {lab=#net12}
N 4530 -5570 4730 -5570 {lab=#net12}
N 4730 -5570 4740 -5560 {lab=#net12}
N 4740 -5560 4870 -5560 {lab=#net12}
N 4870 -5640 4880 -5650 {lab=rowoff_n[6]}
N 4880 -5650 5080 -5650 {lab=rowoff_n[6]}
N 5080 -5650 5090 -5640 {lab=rowoff_n[6]}
N 5090 -5640 5210 -5640 {lab=rowoff_n[6]}
N 4870 -5620 4880 -5630 {lab=row_n[6]}
N 4880 -5630 5080 -5630 {lab=row_n[6]}
N 5080 -5630 5090 -5620 {lab=row_n[6]}
N 5090 -5620 5210 -5620 {lab=row_n[6]}
N 4870 -5600 4880 -5610 {lab=rowon_n[6]}
N 4880 -5610 5080 -5610 {lab=rowon_n[6]}
N 5080 -5610 5090 -5600 {lab=rowon_n[6]}
N 5090 -5600 5210 -5600 {lab=rowon_n[6]}
N 4870 -5580 4880 -5590 {lab=#net11}
N 4880 -5590 5080 -5590 {lab=#net11}
N 5080 -5590 5090 -5580 {lab=#net11}
N 5090 -5580 5210 -5580 {lab=#net11}
N 4870 -5560 4880 -5570 {lab=#net12}
N 4880 -5570 5080 -5570 {lab=#net12}
N 5080 -5570 5090 -5560 {lab=#net12}
N 5090 -5560 5210 -5560 {lab=#net12}
N 5210 -5640 5220 -5650 {lab=rowoff_n[6]}
N 5220 -5650 5420 -5650 {lab=rowoff_n[6]}
N 5420 -5650 5430 -5640 {lab=rowoff_n[6]}
N 5430 -5640 5550 -5640 {lab=rowoff_n[6]}
N 5210 -5620 5220 -5630 {lab=row_n[6]}
N 5220 -5630 5420 -5630 {lab=row_n[6]}
N 5420 -5630 5430 -5620 {lab=row_n[6]}
N 5430 -5620 5550 -5620 {lab=row_n[6]}
N 5210 -5600 5220 -5610 {lab=rowon_n[6]}
N 5220 -5610 5420 -5610 {lab=rowon_n[6]}
N 5420 -5610 5430 -5600 {lab=rowon_n[6]}
N 5430 -5600 5550 -5600 {lab=rowon_n[6]}
N 5210 -5580 5220 -5590 {lab=#net11}
N 5220 -5590 5420 -5590 {lab=#net11}
N 5420 -5590 5430 -5580 {lab=#net11}
N 5430 -5580 5550 -5580 {lab=#net11}
N 5210 -5560 5220 -5570 {lab=#net12}
N 5220 -5570 5420 -5570 {lab=#net12}
N 5420 -5570 5440 -5560 {lab=#net12}
N 5440 -5560 5550 -5560 {lab=#net12}
N 5550 -5640 5560 -5650 {lab=rowoff_n[6]}
N 5560 -5650 5760 -5650 {lab=rowoff_n[6]}
N 5550 -5620 5560 -5630 {lab=row_n[6]}
N 5560 -5630 5760 -5630 {lab=row_n[6]}
N 5760 -5630 5770 -5620 {lab=row_n[6]}
N 5760 -5650 5770 -5640 {lab=rowoff_n[6]}
N 5550 -5600 5560 -5610 {lab=rowon_n[6]}
N 5560 -5610 5760 -5610 {lab=rowon_n[6]}
N 5550 -5580 5560 -5590 {lab=#net11}
N 5560 -5590 5760 -5590 {lab=#net11}
N 5760 -5590 5770 -5580 {lab=#net11}
N 5550 -5560 5560 -5570 {lab=#net12}
N 5560 -5570 5760 -5570 {lab=#net12}
N 5760 -5570 5770 -5560 {lab=#net12}
N 5760 -5610 5770 -5600 {lab=rowon_n[6]}
N 880 -5150 890 -5160 {lab=VDD}
N 890 -5410 890 -5160 {lab=VDD}
N 880 -5420 890 -5410 {lab=VDD}
N 880 -5480 880 -5420 {lab=VDD}
N 900 -5480 900 -5420 {lab=VSS}
N 900 -5420 910 -5410 {lab=VSS}
N 910 -5410 910 -5160 {lab=VSS}
N 900 -5150 910 -5160 {lab=VSS}
N 1210 -5410 1210 -5160 {lab=col_n[0]}
N 1200 -5420 1210 -5410 {lab=col_n[0]}
N 1200 -5480 1200 -5420 {lab=col_n[0]}
N 1220 -5480 1220 -5420 {lab=col[0]}
N 1220 -5420 1230 -5410 {lab=col[0]}
N 1230 -5410 1230 -5160 {lab=col[0]}
N 1540 -5410 1540 -5160 {lab=col_n[1]}
N 1530 -5420 1540 -5410 {lab=col_n[1]}
N 1530 -5480 1530 -5420 {lab=col_n[1]}
N 1550 -5480 1550 -5420 {lab=col[1]}
N 1550 -5420 1560 -5410 {lab=col[1]}
N 1560 -5410 1560 -5160 {lab=col[1]}
N 1890 -5410 1890 -5160 {lab=col_n[2]}
N 1880 -5420 1890 -5410 {lab=col_n[2]}
N 1880 -5480 1880 -5420 {lab=col_n[2]}
N 1900 -5480 1900 -5420 {lab=col[2]}
N 1900 -5420 1910 -5410 {lab=col[2]}
N 1910 -5410 1910 -5160 {lab=col[2]}
N 2240 -5410 2240 -5160 {lab=col_n[3]}
N 2230 -5420 2240 -5410 {lab=col_n[3]}
N 2230 -5480 2230 -5420 {lab=col_n[3]}
N 2250 -5480 2250 -5420 {lab=col[3]}
N 2250 -5420 2260 -5410 {lab=col[3]}
N 2260 -5410 2260 -5160 {lab=col[3]}
N 2590 -5410 2590 -5160 {lab=col_n[4]}
N 2580 -5420 2590 -5410 {lab=col_n[4]}
N 2580 -5480 2580 -5420 {lab=col_n[4]}
N 2600 -5480 2600 -5420 {lab=col[4]}
N 2600 -5420 2610 -5410 {lab=col[4]}
N 2610 -5410 2610 -5160 {lab=col[4]}
N 2930 -5410 2930 -5160 {lab=col_n[5]}
N 2920 -5420 2930 -5410 {lab=col_n[5]}
N 2920 -5480 2920 -5420 {lab=col_n[5]}
N 2940 -5480 2940 -5420 {lab=col[5]}
N 2940 -5420 2950 -5410 {lab=col[5]}
N 2950 -5410 2950 -5160 {lab=col[5]}
N 3280 -5410 3280 -5160 {lab=col_n[6]}
N 3270 -5420 3280 -5410 {lab=col_n[6]}
N 3270 -5480 3270 -5420 {lab=col_n[6]}
N 3290 -5480 3290 -5420 {lab=col[6]}
N 3290 -5420 3300 -5410 {lab=col[6]}
N 3300 -5410 3300 -5160 {lab=col[6]}
N 3640 -5410 3640 -5160 {lab=col_n[7]}
N 3630 -5420 3640 -5410 {lab=col_n[7]}
N 3630 -5480 3630 -5420 {lab=col_n[7]}
N 3650 -5480 3650 -5420 {lab=col[7]}
N 3650 -5420 3660 -5410 {lab=col[7]}
N 3660 -5410 3660 -5160 {lab=col[7]}
N 3970 -5410 3970 -5160 {lab=col_n[8]}
N 3960 -5420 3970 -5410 {lab=col_n[8]}
N 3960 -5480 3960 -5420 {lab=col_n[8]}
N 3980 -5480 3980 -5420 {lab=col[8]}
N 3980 -5420 3990 -5410 {lab=col[8]}
N 3990 -5410 3990 -5160 {lab=col[8]}
N 4300 -5410 4300 -5160 {lab=col_n[9]}
N 4290 -5420 4300 -5410 {lab=col_n[9]}
N 4290 -5480 4290 -5420 {lab=col_n[9]}
N 4310 -5480 4310 -5420 {lab=col[9]}
N 4310 -5420 4320 -5410 {lab=col[9]}
N 4320 -5410 4320 -5160 {lab=col[9]}
N 4650 -5410 4650 -5160 {lab=col_n[10]}
N 4640 -5420 4650 -5410 {lab=col_n[10]}
N 4640 -5480 4640 -5420 {lab=col_n[10]}
N 4660 -5480 4660 -5420 {lab=col[10]}
N 4660 -5420 4670 -5410 {lab=col[10]}
N 4670 -5410 4670 -5160 {lab=col[10]}
N 5000 -5410 5000 -5160 {lab=col_n[11]}
N 4990 -5420 5000 -5410 {lab=col_n[11]}
N 4990 -5480 4990 -5420 {lab=col_n[11]}
N 5010 -5480 5010 -5420 {lab=col[11]}
N 5010 -5420 5020 -5410 {lab=col[11]}
N 5020 -5410 5020 -5160 {lab=col[11]}
N 5340 -5410 5340 -5160 {lab=col_n[12]}
N 5330 -5420 5340 -5410 {lab=col_n[12]}
N 5330 -5480 5330 -5420 {lab=col_n[12]}
N 5350 -5480 5350 -5420 {lab=col[12]}
N 5350 -5420 5360 -5410 {lab=col[12]}
N 5360 -5410 5360 -5160 {lab=col[12]}
N 5680 -5410 5680 -5160 {lab=VDD}
N 5670 -5420 5680 -5410 {lab=VDD}
N 5670 -5480 5670 -5420 {lab=VDD}
N 5690 -5480 5690 -5420 {lab=VSS}
N 5690 -5420 5700 -5410 {lab=VSS}
N 5700 -5410 5700 -5160 {lab=VSS}
N 5690 -5150 5700 -5160 {lab=VSS}
N 5670 -5150 5680 -5160 {lab=VDD}
N 5330 -5150 5340 -5160 {lab=col_n[12]}
N 5350 -5150 5360 -5160 {lab=col[12]}
N 4990 -5150 5000 -5160 {lab=col_n[11]}
N 5010 -5150 5020 -5160 {lab=col[11]}
N 4640 -5150 4650 -5160 {lab=col_n[10]}
N 4660 -5150 4670 -5160 {lab=col[10]}
N 4310 -5150 4320 -5160 {lab=col[9]}
N 4290 -5150 4300 -5160 {lab=col_n[9]}
N 3980 -5150 3990 -5160 {lab=col[8]}
N 3960 -5150 3970 -5160 {lab=col_n[8]}
N 3630 -5150 3640 -5160 {lab=col_n[7]}
N 3650 -5150 3660 -5160 {lab=col[7]}
N 3270 -5150 3280 -5160 {lab=col_n[6]}
N 3290 -5150 3300 -5160 {lab=col[6]}
N 2940 -5150 2950 -5160 {lab=col[5]}
N 2920 -5150 2930 -5160 {lab=col_n[5]}
N 2600 -5150 2610 -5160 {lab=col[4]}
N 2580 -5150 2590 -5160 {lab=col_n[4]}
N 2250 -5150 2260 -5160 {lab=col[3]}
N 2230 -5150 2240 -5160 {lab=col_n[3]}
N 1900 -5150 1910 -5160 {lab=col[2]}
N 1880 -5150 1890 -5160 {lab=col_n[2]}
N 1550 -5150 1560 -5160 {lab=col[1]}
N 1530 -5150 1540 -5160 {lab=col_n[1]}
N 1200 -5150 1210 -5160 {lab=col_n[0]}
N 1220 -5150 1230 -5160 {lab=col[0]}
N 880 -5150 880 -5110 {lab=VDD}
N 900 -5150 900 -5110 {lab=VSS}
N 800 -5800 800 -5790 {
lab=VSS}
N 1120 -5800 1120 -5790 {
lab=VSS}
N 1450 -5800 1450 -5790 {
lab=VSS}
N 1800 -5800 1800 -5790 {
lab=VSS}
N 2150 -5800 2150 -5790 {
lab=VSS}
N 2500 -5800 2500 -5790 {
lab=VSS}
N 2840 -5800 2840 -5790 {
lab=VSS}
N 3190 -5800 3190 -5790 {
lab=VSS}
N 3550 -5800 3550 -5790 {
lab=VSS}
N 3880 -5800 3880 -5790 {
lab=VSS}
N 4210 -5800 4210 -5790 {
lab=VSS}
N 4560 -5800 4560 -5790 {
lab=VSS}
N 4910 -5800 4910 -5790 {
lab=VSS}
N 5250 -5800 5250 -5790 {
lab=VSS}
N 5590 -5800 5590 -5790 {
lab=VSS}
N 5610 -6040 5610 -6020 {
lab=vcm}
N 5590 -6030 5590 -6020 {
lab=VDD}
N 5650 -6040 5650 -6020 {
lab=ctop}
N 4930 -6040 4930 -6020 {
lab=vcm}
N 4910 -6030 4910 -6020 {
lab=VDD}
N 4970 -6040 4970 -6020 {
lab=ctop}
N 5270 -6040 5270 -6020 {
lab=vcm}
N 5250 -6030 5250 -6020 {
lab=VDD}
N 5310 -6040 5310 -6020 {
lab=ctop}
N 4580 -6040 4580 -6020 {
lab=vcm}
N 4560 -6030 4560 -6020 {
lab=VDD}
N 4620 -6040 4620 -6020 {
lab=ctop}
N 4230 -6040 4230 -6020 {
lab=vcm}
N 4210 -6030 4210 -6020 {
lab=VDD}
N 4270 -6040 4270 -6020 {
lab=ctop}
N 3900 -6040 3900 -6020 {
lab=vcm}
N 3880 -6030 3880 -6020 {
lab=VDD}
N 3940 -6040 3940 -6020 {
lab=ctop}
N 3570 -6040 3570 -6020 {
lab=vcm}
N 3550 -6030 3550 -6020 {
lab=VDD}
N 3610 -6040 3610 -6020 {
lab=ctop}
N 3210 -6040 3210 -6020 {
lab=vcm}
N 3190 -6030 3190 -6020 {
lab=VDD}
N 3250 -6040 3250 -6020 {
lab=ctop}
N 2860 -6040 2860 -6020 {
lab=vcm}
N 2840 -6030 2840 -6020 {
lab=VDD}
N 2900 -6040 2900 -6020 {
lab=ctop}
N 2520 -6040 2520 -6020 {
lab=vcm}
N 2500 -6030 2500 -6020 {
lab=VDD}
N 2560 -6040 2560 -6020 {
lab=ctop}
N 2170 -6040 2170 -6020 {
lab=vcm}
N 2150 -6030 2150 -6020 {
lab=VDD}
N 2210 -6040 2210 -6020 {
lab=ctop}
N 1820 -6040 1820 -6020 {
lab=vcm}
N 1800 -6030 1800 -6020 {
lab=VDD}
N 1860 -6040 1860 -6020 {
lab=ctop}
N 1470 -6040 1470 -6020 {
lab=vcm}
N 1450 -6030 1450 -6020 {
lab=VDD}
N 1510 -6040 1510 -6020 {
lab=ctop}
N 1140 -6040 1140 -6020 {
lab=vcm}
N 1120 -6030 1120 -6020 {
lab=VDD}
N 1180 -6040 1180 -6020 {
lab=ctop}
N 820 -6040 820 -6020 {
lab=vcm}
N 800 -6030 800 -6020 {
lab=VDD}
N 860 -6040 860 -6020 {
lab=ctop}
N 740 -5880 760 -5880 {
lab=sample_n}
N 740 -5900 760 -5900 {
lab=sample}
N 740 -5920 760 -5920 {
lab=rowon_n[7]}
N 740 -5940 760 -5940 {
lab=row_n[7]}
N 740 -5960 760 -5960 {
lab=rowoff_n[7]}
N 980 -5900 1080 -5900 {lab=#net13}
N 980 -5880 1080 -5880 {lab=#net14}
N 760 -5960 770 -5970 {lab=rowoff_n[7]}
N 770 -5970 990 -5970 {lab=rowoff_n[7]}
N 990 -5970 1000 -5960 {lab=rowoff_n[7]}
N 1000 -5960 1080 -5960 {lab=rowoff_n[7]}
N 760 -5940 770 -5950 {lab=row_n[7]}
N 770 -5950 990 -5950 {lab=row_n[7]}
N 990 -5950 1000 -5940 {lab=row_n[7]}
N 1000 -5940 1080 -5940 {lab=row_n[7]}
N 760 -5920 770 -5930 {lab=rowon_n[7]}
N 770 -5930 990 -5930 {lab=rowon_n[7]}
N 990 -5930 1000 -5920 {lab=rowon_n[7]}
N 1000 -5920 1080 -5920 {lab=rowon_n[7]}
N 1080 -5960 1090 -5970 {lab=rowoff_n[7]}
N 1080 -5940 1090 -5950 {lab=row_n[7]}
N 1090 -5950 1290 -5950 {lab=row_n[7]}
N 1290 -5950 1300 -5940 {lab=row_n[7]}
N 1300 -5940 1410 -5940 {lab=row_n[7]}
N 1090 -5970 1290 -5970 {lab=rowoff_n[7]}
N 1290 -5970 1300 -5960 {lab=rowoff_n[7]}
N 1300 -5960 1410 -5960 {lab=rowoff_n[7]}
N 1080 -5920 1090 -5930 {lab=rowon_n[7]}
N 1090 -5930 1290 -5930 {lab=rowon_n[7]}
N 1290 -5930 1300 -5920 {lab=rowon_n[7]}
N 1300 -5920 1410 -5920 {lab=rowon_n[7]}
N 1080 -5900 1090 -5910 {lab=#net13}
N 1090 -5910 1290 -5910 {lab=#net13}
N 1290 -5910 1300 -5900 {lab=#net13}
N 1300 -5900 1410 -5900 {lab=#net13}
N 1080 -5880 1090 -5890 {lab=#net14}
N 1090 -5890 1290 -5890 {lab=#net14}
N 1290 -5890 1300 -5880 {lab=#net14}
N 1300 -5880 1410 -5880 {lab=#net14}
N 1410 -5940 1420 -5950 {lab=row_n[7]}
N 1420 -5950 1620 -5950 {lab=row_n[7]}
N 1620 -5950 1630 -5940 {lab=row_n[7]}
N 1630 -5940 1760 -5940 {lab=row_n[7]}
N 1410 -5920 1420 -5930 {lab=rowon_n[7]}
N 1420 -5930 1620 -5930 {lab=rowon_n[7]}
N 1620 -5930 1630 -5920 {lab=rowon_n[7]}
N 1630 -5920 1760 -5920 {lab=rowon_n[7]}
N 1410 -5900 1420 -5910 {lab=#net13}
N 1420 -5910 1620 -5910 {lab=#net13}
N 1620 -5910 1630 -5900 {lab=#net13}
N 1630 -5900 1760 -5900 {lab=#net13}
N 1410 -5880 1430 -5890 {lab=#net14}
N 1430 -5890 1620 -5890 {lab=#net14}
N 1620 -5890 1630 -5880 {lab=#net14}
N 1630 -5880 1760 -5880 {lab=#net14}
N 1410 -5960 1420 -5970 {lab=rowoff_n[7]}
N 1420 -5970 1620 -5970 {lab=rowoff_n[7]}
N 1620 -5970 1630 -5960 {lab=rowoff_n[7]}
N 1630 -5960 1760 -5960 {lab=rowoff_n[7]}
N 1760 -5960 1770 -5970 {lab=rowoff_n[7]}
N 1770 -5970 1970 -5970 {lab=rowoff_n[7]}
N 1970 -5970 1980 -5960 {lab=rowoff_n[7]}
N 1980 -5960 2110 -5960 {lab=rowoff_n[7]}
N 1760 -5940 1770 -5950 {lab=row_n[7]}
N 1770 -5950 1970 -5950 {lab=row_n[7]}
N 1970 -5950 1980 -5940 {lab=row_n[7]}
N 1980 -5940 2110 -5940 {lab=row_n[7]}
N 1760 -5920 1770 -5930 {lab=rowon_n[7]}
N 1770 -5930 1970 -5930 {lab=rowon_n[7]}
N 1970 -5930 1980 -5920 {lab=rowon_n[7]}
N 1980 -5920 2110 -5920 {lab=rowon_n[7]}
N 1760 -5900 1770 -5910 {lab=#net13}
N 1770 -5910 1970 -5910 {lab=#net13}
N 1970 -5910 1980 -5900 {lab=#net13}
N 1980 -5900 2110 -5900 {lab=#net13}
N 1760 -5880 1770 -5890 {lab=#net14}
N 1770 -5890 1970 -5890 {lab=#net14}
N 1970 -5890 1980 -5880 {lab=#net14}
N 1980 -5880 2110 -5880 {lab=#net14}
N 2110 -5960 2120 -5970 {lab=rowoff_n[7]}
N 2120 -5970 2320 -5970 {lab=rowoff_n[7]}
N 2320 -5970 2330 -5960 {lab=rowoff_n[7]}
N 2330 -5960 2460 -5960 {lab=rowoff_n[7]}
N 2110 -5940 2120 -5950 {lab=row_n[7]}
N 2120 -5950 2320 -5950 {lab=row_n[7]}
N 2320 -5950 2330 -5940 {lab=row_n[7]}
N 2330 -5940 2460 -5940 {lab=row_n[7]}
N 2110 -5920 2120 -5930 {lab=rowon_n[7]}
N 2120 -5930 2320 -5930 {lab=rowon_n[7]}
N 2320 -5930 2330 -5920 {lab=rowon_n[7]}
N 2330 -5920 2460 -5920 {lab=rowon_n[7]}
N 2320 -5910 2330 -5900 {lab=#net13}
N 2330 -5900 2460 -5900 {lab=#net13}
N 2110 -5880 2120 -5890 {lab=#net14}
N 2120 -5890 2320 -5890 {lab=#net14}
N 2320 -5890 2330 -5880 {lab=#net14}
N 2330 -5880 2460 -5880 {lab=#net14}
N 2110 -5900 2120 -5910 {lab=#net13}
N 2120 -5910 2320 -5910 {lab=#net13}
N 2460 -5960 2470 -5970 {lab=rowoff_n[7]}
N 2470 -5970 2670 -5970 {lab=rowoff_n[7]}
N 2670 -5970 2680 -5960 {lab=rowoff_n[7]}
N 2680 -5960 2800 -5960 {lab=rowoff_n[7]}
N 2460 -5940 2470 -5950 {lab=row_n[7]}
N 2470 -5950 2670 -5950 {lab=row_n[7]}
N 2670 -5950 2680 -5940 {lab=row_n[7]}
N 2680 -5940 2800 -5940 {lab=row_n[7]}
N 2460 -5920 2470 -5930 {lab=rowon_n[7]}
N 2470 -5930 2670 -5930 {lab=rowon_n[7]}
N 2670 -5930 2680 -5920 {lab=rowon_n[7]}
N 2680 -5920 2800 -5920 {lab=rowon_n[7]}
N 2460 -5900 2470 -5910 {lab=#net13}
N 2470 -5910 2670 -5910 {lab=#net13}
N 2670 -5910 2680 -5900 {lab=#net13}
N 2680 -5900 2800 -5900 {lab=#net13}
N 2460 -5880 2470 -5890 {lab=#net14}
N 2470 -5890 2670 -5890 {lab=#net14}
N 2670 -5890 2680 -5880 {lab=#net14}
N 2680 -5880 2800 -5880 {lab=#net14}
N 2800 -5960 2810 -5970 {lab=rowoff_n[7]}
N 2810 -5970 3010 -5970 {lab=rowoff_n[7]}
N 3010 -5970 3020 -5960 {lab=rowoff_n[7]}
N 3020 -5960 3150 -5960 {lab=rowoff_n[7]}
N 2800 -5940 2810 -5950 {lab=row_n[7]}
N 2810 -5950 3010 -5950 {lab=row_n[7]}
N 3010 -5950 3020 -5940 {lab=row_n[7]}
N 3020 -5940 3150 -5940 {lab=row_n[7]}
N 2800 -5920 2810 -5930 {lab=rowon_n[7]}
N 2810 -5930 3010 -5930 {lab=rowon_n[7]}
N 3010 -5930 3020 -5920 {lab=rowon_n[7]}
N 3020 -5920 3150 -5920 {lab=rowon_n[7]}
N 2800 -5900 2810 -5910 {lab=#net13}
N 2810 -5910 3010 -5910 {lab=#net13}
N 2800 -5880 2810 -5890 {lab=#net14}
N 2810 -5890 3010 -5890 {lab=#net14}
N 3010 -5890 3020 -5880 {lab=#net14}
N 3020 -5880 3150 -5880 {lab=#net14}
N 3010 -5910 3020 -5900 {lab=#net13}
N 3020 -5900 3150 -5900 {lab=#net13}
N 3150 -5960 3160 -5970 {lab=rowoff_n[7]}
N 3160 -5970 3360 -5970 {lab=rowoff_n[7]}
N 3360 -5970 3370 -5960 {lab=rowoff_n[7]}
N 3370 -5960 3510 -5960 {lab=rowoff_n[7]}
N 3150 -5940 3160 -5950 {lab=row_n[7]}
N 3160 -5950 3360 -5950 {lab=row_n[7]}
N 3360 -5950 3370 -5940 {lab=row_n[7]}
N 3370 -5940 3510 -5940 {lab=row_n[7]}
N 3150 -5920 3160 -5930 {lab=rowon_n[7]}
N 3160 -5930 3360 -5930 {lab=rowon_n[7]}
N 3360 -5930 3370 -5920 {lab=rowon_n[7]}
N 3370 -5920 3510 -5920 {lab=rowon_n[7]}
N 3150 -5900 3160 -5910 {lab=#net13}
N 3160 -5910 3360 -5910 {lab=#net13}
N 3360 -5910 3370 -5900 {lab=#net13}
N 3370 -5900 3510 -5900 {lab=#net13}
N 3150 -5880 3160 -5890 {lab=#net14}
N 3160 -5890 3360 -5890 {lab=#net14}
N 3360 -5890 3370 -5880 {lab=#net14}
N 3370 -5880 3510 -5880 {lab=#net14}
N 3510 -5960 3520 -5970 {lab=rowoff_n[7]}
N 3520 -5970 3720 -5970 {lab=rowoff_n[7]}
N 3720 -5970 3730 -5960 {lab=rowoff_n[7]}
N 3730 -5960 3840 -5960 {lab=rowoff_n[7]}
N 3510 -5940 3520 -5950 {lab=row_n[7]}
N 3520 -5950 3720 -5950 {lab=row_n[7]}
N 3720 -5950 3730 -5940 {lab=row_n[7]}
N 3730 -5940 3840 -5940 {lab=row_n[7]}
N 3510 -5920 3520 -5930 {lab=rowon_n[7]}
N 3520 -5930 3720 -5930 {lab=rowon_n[7]}
N 3720 -5930 3730 -5920 {lab=rowon_n[7]}
N 3730 -5920 3840 -5920 {lab=rowon_n[7]}
N 3510 -5900 3520 -5910 {lab=#net13}
N 3520 -5910 3720 -5910 {lab=#net13}
N 3720 -5910 3730 -5900 {lab=#net13}
N 3730 -5900 3840 -5900 {lab=#net13}
N 3510 -5880 3520 -5890 {lab=#net14}
N 3520 -5890 3720 -5890 {lab=#net14}
N 3720 -5890 3730 -5880 {lab=#net14}
N 3730 -5880 3840 -5880 {lab=#net14}
N 3840 -5960 3850 -5970 {lab=rowoff_n[7]}
N 3850 -5970 4050 -5970 {lab=rowoff_n[7]}
N 4050 -5970 4060 -5960 {lab=rowoff_n[7]}
N 4060 -5960 4170 -5960 {lab=rowoff_n[7]}
N 3840 -5940 3850 -5950 {lab=row_n[7]}
N 3850 -5950 4050 -5950 {lab=row_n[7]}
N 4050 -5950 4060 -5940 {lab=row_n[7]}
N 4060 -5940 4170 -5940 {lab=row_n[7]}
N 3840 -5920 3850 -5930 {lab=rowon_n[7]}
N 3850 -5930 4050 -5930 {lab=rowon_n[7]}
N 4050 -5930 4060 -5920 {lab=rowon_n[7]}
N 4060 -5920 4170 -5920 {lab=rowon_n[7]}
N 3840 -5900 3850 -5910 {lab=#net13}
N 3850 -5910 4050 -5910 {lab=#net13}
N 4050 -5910 4060 -5900 {lab=#net13}
N 4060 -5900 4170 -5900 {lab=#net13}
N 3840 -5880 3850 -5890 {lab=#net14}
N 3850 -5890 4050 -5890 {lab=#net14}
N 4050 -5890 4070 -5880 {lab=#net14}
N 4070 -5880 4170 -5880 {lab=#net14}
N 4170 -5960 4180 -5970 {lab=rowoff_n[7]}
N 4180 -5970 4380 -5970 {lab=rowoff_n[7]}
N 4380 -5970 4390 -5960 {lab=rowoff_n[7]}
N 4390 -5960 4520 -5960 {lab=rowoff_n[7]}
N 4170 -5940 4180 -5950 {lab=row_n[7]}
N 4180 -5950 4380 -5950 {lab=row_n[7]}
N 4380 -5950 4390 -5940 {lab=row_n[7]}
N 4390 -5940 4520 -5940 {lab=row_n[7]}
N 4170 -5920 4180 -5930 {lab=rowon_n[7]}
N 4180 -5930 4380 -5930 {lab=rowon_n[7]}
N 4380 -5930 4390 -5920 {lab=rowon_n[7]}
N 4390 -5920 4520 -5920 {lab=rowon_n[7]}
N 4170 -5900 4180 -5910 {lab=#net13}
N 4180 -5910 4380 -5910 {lab=#net13}
N 4380 -5910 4390 -5900 {lab=#net13}
N 4390 -5900 4520 -5900 {lab=#net13}
N 4170 -5880 4180 -5890 {lab=#net14}
N 4180 -5890 4380 -5890 {lab=#net14}
N 4380 -5890 4390 -5880 {lab=#net14}
N 4390 -5880 4520 -5880 {lab=#net14}
N 4520 -5960 4530 -5970 {lab=rowoff_n[7]}
N 4530 -5970 4730 -5970 {lab=rowoff_n[7]}
N 4730 -5970 4740 -5960 {lab=rowoff_n[7]}
N 4740 -5960 4870 -5960 {lab=rowoff_n[7]}
N 4520 -5940 4530 -5950 {lab=row_n[7]}
N 4530 -5950 4730 -5950 {lab=row_n[7]}
N 4520 -5920 4530 -5930 {lab=rowon_n[7]}
N 4530 -5930 4730 -5930 {lab=rowon_n[7]}
N 4730 -5930 4740 -5920 {lab=rowon_n[7]}
N 4740 -5920 4870 -5920 {lab=rowon_n[7]}
N 4730 -5950 4740 -5940 {lab=row_n[7]}
N 4740 -5940 4870 -5940 {lab=row_n[7]}
N 4520 -5900 4530 -5910 {lab=#net13}
N 4530 -5910 4730 -5910 {lab=#net13}
N 4730 -5910 4740 -5900 {lab=#net13}
N 4740 -5900 4870 -5900 {lab=#net13}
N 4520 -5880 4530 -5890 {lab=#net14}
N 4530 -5890 4730 -5890 {lab=#net14}
N 4730 -5890 4740 -5880 {lab=#net14}
N 4740 -5880 4870 -5880 {lab=#net14}
N 4870 -5960 4880 -5970 {lab=rowoff_n[7]}
N 4880 -5970 5080 -5970 {lab=rowoff_n[7]}
N 5080 -5970 5090 -5960 {lab=rowoff_n[7]}
N 5090 -5960 5210 -5960 {lab=rowoff_n[7]}
N 4870 -5940 4880 -5950 {lab=row_n[7]}
N 4880 -5950 5080 -5950 {lab=row_n[7]}
N 5080 -5950 5090 -5940 {lab=row_n[7]}
N 5090 -5940 5210 -5940 {lab=row_n[7]}
N 4870 -5920 4880 -5930 {lab=rowon_n[7]}
N 4880 -5930 5080 -5930 {lab=rowon_n[7]}
N 5080 -5930 5090 -5920 {lab=rowon_n[7]}
N 5090 -5920 5210 -5920 {lab=rowon_n[7]}
N 4870 -5900 4880 -5910 {lab=#net13}
N 4880 -5910 5080 -5910 {lab=#net13}
N 5080 -5910 5090 -5900 {lab=#net13}
N 5090 -5900 5210 -5900 {lab=#net13}
N 4870 -5880 4880 -5890 {lab=#net14}
N 4880 -5890 5080 -5890 {lab=#net14}
N 5080 -5890 5090 -5880 {lab=#net14}
N 5090 -5880 5210 -5880 {lab=#net14}
N 5210 -5960 5220 -5970 {lab=rowoff_n[7]}
N 5220 -5970 5420 -5970 {lab=rowoff_n[7]}
N 5420 -5970 5430 -5960 {lab=rowoff_n[7]}
N 5430 -5960 5550 -5960 {lab=rowoff_n[7]}
N 5210 -5940 5220 -5950 {lab=row_n[7]}
N 5220 -5950 5420 -5950 {lab=row_n[7]}
N 5420 -5950 5430 -5940 {lab=row_n[7]}
N 5430 -5940 5550 -5940 {lab=row_n[7]}
N 5210 -5920 5220 -5930 {lab=rowon_n[7]}
N 5220 -5930 5420 -5930 {lab=rowon_n[7]}
N 5420 -5930 5430 -5920 {lab=rowon_n[7]}
N 5430 -5920 5550 -5920 {lab=rowon_n[7]}
N 5210 -5900 5220 -5910 {lab=#net13}
N 5220 -5910 5420 -5910 {lab=#net13}
N 5420 -5910 5430 -5900 {lab=#net13}
N 5430 -5900 5550 -5900 {lab=#net13}
N 5210 -5880 5220 -5890 {lab=#net14}
N 5220 -5890 5420 -5890 {lab=#net14}
N 5420 -5890 5440 -5880 {lab=#net14}
N 5440 -5880 5550 -5880 {lab=#net14}
N 5550 -5960 5560 -5970 {lab=rowoff_n[7]}
N 5560 -5970 5760 -5970 {lab=rowoff_n[7]}
N 5550 -5940 5560 -5950 {lab=row_n[7]}
N 5560 -5950 5760 -5950 {lab=row_n[7]}
N 5760 -5950 5770 -5940 {lab=row_n[7]}
N 5760 -5970 5770 -5960 {lab=rowoff_n[7]}
N 5550 -5920 5560 -5930 {lab=rowon_n[7]}
N 5560 -5930 5760 -5930 {lab=rowon_n[7]}
N 5550 -5900 5560 -5910 {lab=#net13}
N 5560 -5910 5760 -5910 {lab=#net13}
N 5760 -5910 5770 -5900 {lab=#net13}
N 5550 -5880 5560 -5890 {lab=#net14}
N 5560 -5890 5760 -5890 {lab=#net14}
N 5760 -5890 5770 -5880 {lab=#net14}
N 5760 -5930 5770 -5920 {lab=rowon_n[7]}
N 800 -6130 800 -6120 {
lab=VSS}
N 1120 -6130 1120 -6120 {
lab=VSS}
N 1450 -6130 1450 -6120 {
lab=VSS}
N 1800 -6130 1800 -6120 {
lab=VSS}
N 2150 -6130 2150 -6120 {
lab=VSS}
N 2500 -6130 2500 -6120 {
lab=VSS}
N 2840 -6130 2840 -6120 {
lab=VSS}
N 3190 -6130 3190 -6120 {
lab=VSS}
N 3550 -6130 3550 -6120 {
lab=VSS}
N 3880 -6130 3880 -6120 {
lab=VSS}
N 4210 -6130 4210 -6120 {
lab=VSS}
N 4560 -6130 4560 -6120 {
lab=VSS}
N 4910 -6130 4910 -6120 {
lab=VSS}
N 5250 -6130 5250 -6120 {
lab=VSS}
N 5590 -6130 5590 -6120 {
lab=VSS}
N 5610 -6370 5610 -6350 {
lab=vcm}
N 5590 -6360 5590 -6350 {
lab=VDD}
N 5650 -6370 5650 -6350 {
lab=ctop}
N 4930 -6370 4930 -6350 {
lab=vcm}
N 4910 -6360 4910 -6350 {
lab=VDD}
N 4970 -6370 4970 -6350 {
lab=ctop}
N 5270 -6370 5270 -6350 {
lab=vcm}
N 5250 -6360 5250 -6350 {
lab=VDD}
N 5310 -6370 5310 -6350 {
lab=ctop}
N 4580 -6370 4580 -6350 {
lab=vcm}
N 4560 -6360 4560 -6350 {
lab=VDD}
N 4620 -6370 4620 -6350 {
lab=ctop}
N 4230 -6370 4230 -6350 {
lab=vcm}
N 4210 -6360 4210 -6350 {
lab=VDD}
N 4270 -6370 4270 -6350 {
lab=ctop}
N 3900 -6370 3900 -6350 {
lab=vcm}
N 3880 -6360 3880 -6350 {
lab=VDD}
N 3940 -6370 3940 -6350 {
lab=ctop}
N 3570 -6370 3570 -6350 {
lab=vcm}
N 3550 -6360 3550 -6350 {
lab=VDD}
N 3610 -6370 3610 -6350 {
lab=ctop}
N 3210 -6370 3210 -6350 {
lab=vcm}
N 3190 -6360 3190 -6350 {
lab=VDD}
N 3250 -6370 3250 -6350 {
lab=ctop}
N 2860 -6370 2860 -6350 {
lab=vcm}
N 2840 -6360 2840 -6350 {
lab=VDD}
N 2900 -6370 2900 -6350 {
lab=ctop}
N 2520 -6370 2520 -6350 {
lab=vcm}
N 2500 -6360 2500 -6350 {
lab=VDD}
N 2560 -6370 2560 -6350 {
lab=ctop}
N 2170 -6370 2170 -6350 {
lab=vcm}
N 2150 -6360 2150 -6350 {
lab=VDD}
N 2210 -6370 2210 -6350 {
lab=ctop}
N 1820 -6370 1820 -6350 {
lab=vcm}
N 1800 -6360 1800 -6350 {
lab=VDD}
N 1860 -6370 1860 -6350 {
lab=ctop}
N 1470 -6370 1470 -6350 {
lab=vcm}
N 1450 -6360 1450 -6350 {
lab=VDD}
N 1510 -6370 1510 -6350 {
lab=ctop}
N 1140 -6370 1140 -6350 {
lab=vcm}
N 1120 -6360 1120 -6350 {
lab=VDD}
N 1180 -6370 1180 -6350 {
lab=ctop}
N 820 -6370 820 -6350 {
lab=vcm}
N 800 -6360 800 -6350 {
lab=VDD}
N 860 -6370 860 -6350 {
lab=ctop}
N 740 -6210 760 -6210 {
lab=sample_n}
N 740 -6230 760 -6230 {
lab=sample}
N 740 -6250 760 -6250 {
lab=rowon_n[8]}
N 740 -6270 760 -6270 {
lab=row_n[8]}
N 740 -6290 760 -6290 {
lab=rowoff_n[8]}
N 980 -6230 1080 -6230 {lab=#net15}
N 980 -6210 1080 -6210 {lab=#net16}
N 760 -6290 770 -6300 {lab=rowoff_n[8]}
N 770 -6300 990 -6300 {lab=rowoff_n[8]}
N 990 -6300 1000 -6290 {lab=rowoff_n[8]}
N 1000 -6290 1080 -6290 {lab=rowoff_n[8]}
N 760 -6270 770 -6280 {lab=row_n[8]}
N 770 -6280 990 -6280 {lab=row_n[8]}
N 990 -6280 1000 -6270 {lab=row_n[8]}
N 1000 -6270 1080 -6270 {lab=row_n[8]}
N 760 -6250 770 -6260 {lab=rowon_n[8]}
N 770 -6260 990 -6260 {lab=rowon_n[8]}
N 990 -6260 1000 -6250 {lab=rowon_n[8]}
N 1000 -6250 1080 -6250 {lab=rowon_n[8]}
N 1080 -6290 1090 -6300 {lab=rowoff_n[8]}
N 1080 -6270 1090 -6280 {lab=row_n[8]}
N 1090 -6280 1290 -6280 {lab=row_n[8]}
N 1290 -6280 1300 -6270 {lab=row_n[8]}
N 1300 -6270 1410 -6270 {lab=row_n[8]}
N 1090 -6300 1290 -6300 {lab=rowoff_n[8]}
N 1290 -6300 1300 -6290 {lab=rowoff_n[8]}
N 1300 -6290 1410 -6290 {lab=rowoff_n[8]}
N 1080 -6250 1090 -6260 {lab=rowon_n[8]}
N 1090 -6260 1290 -6260 {lab=rowon_n[8]}
N 1290 -6260 1300 -6250 {lab=rowon_n[8]}
N 1300 -6250 1410 -6250 {lab=rowon_n[8]}
N 1080 -6230 1090 -6240 {lab=#net15}
N 1090 -6240 1290 -6240 {lab=#net15}
N 1290 -6240 1300 -6230 {lab=#net15}
N 1300 -6230 1410 -6230 {lab=#net15}
N 1080 -6210 1090 -6220 {lab=#net16}
N 1090 -6220 1290 -6220 {lab=#net16}
N 1290 -6220 1300 -6210 {lab=#net16}
N 1300 -6210 1410 -6210 {lab=#net16}
N 1410 -6270 1420 -6280 {lab=row_n[8]}
N 1420 -6280 1620 -6280 {lab=row_n[8]}
N 1620 -6280 1630 -6270 {lab=row_n[8]}
N 1630 -6270 1760 -6270 {lab=row_n[8]}
N 1410 -6250 1420 -6260 {lab=rowon_n[8]}
N 1420 -6260 1620 -6260 {lab=rowon_n[8]}
N 1620 -6260 1630 -6250 {lab=rowon_n[8]}
N 1630 -6250 1760 -6250 {lab=rowon_n[8]}
N 1410 -6230 1420 -6240 {lab=#net15}
N 1420 -6240 1620 -6240 {lab=#net15}
N 1620 -6240 1630 -6230 {lab=#net15}
N 1630 -6230 1760 -6230 {lab=#net15}
N 1410 -6210 1430 -6220 {lab=#net16}
N 1430 -6220 1620 -6220 {lab=#net16}
N 1620 -6220 1630 -6210 {lab=#net16}
N 1630 -6210 1760 -6210 {lab=#net16}
N 1410 -6290 1420 -6300 {lab=rowoff_n[8]}
N 1420 -6300 1620 -6300 {lab=rowoff_n[8]}
N 1620 -6300 1630 -6290 {lab=rowoff_n[8]}
N 1630 -6290 1760 -6290 {lab=rowoff_n[8]}
N 1760 -6290 1770 -6300 {lab=rowoff_n[8]}
N 1770 -6300 1970 -6300 {lab=rowoff_n[8]}
N 1970 -6300 1980 -6290 {lab=rowoff_n[8]}
N 1980 -6290 2110 -6290 {lab=rowoff_n[8]}
N 1760 -6270 1770 -6280 {lab=row_n[8]}
N 1770 -6280 1970 -6280 {lab=row_n[8]}
N 1970 -6280 1980 -6270 {lab=row_n[8]}
N 1980 -6270 2110 -6270 {lab=row_n[8]}
N 1760 -6250 1770 -6260 {lab=rowon_n[8]}
N 1770 -6260 1970 -6260 {lab=rowon_n[8]}
N 1970 -6260 1980 -6250 {lab=rowon_n[8]}
N 1980 -6250 2110 -6250 {lab=rowon_n[8]}
N 1760 -6230 1770 -6240 {lab=#net15}
N 1770 -6240 1970 -6240 {lab=#net15}
N 1970 -6240 1980 -6230 {lab=#net15}
N 1980 -6230 2110 -6230 {lab=#net15}
N 1760 -6210 1770 -6220 {lab=#net16}
N 1770 -6220 1970 -6220 {lab=#net16}
N 1970 -6220 1980 -6210 {lab=#net16}
N 1980 -6210 2110 -6210 {lab=#net16}
N 2110 -6290 2120 -6300 {lab=rowoff_n[8]}
N 2120 -6300 2320 -6300 {lab=rowoff_n[8]}
N 2320 -6300 2330 -6290 {lab=rowoff_n[8]}
N 2330 -6290 2460 -6290 {lab=rowoff_n[8]}
N 2110 -6270 2120 -6280 {lab=row_n[8]}
N 2120 -6280 2320 -6280 {lab=row_n[8]}
N 2320 -6280 2330 -6270 {lab=row_n[8]}
N 2330 -6270 2460 -6270 {lab=row_n[8]}
N 2110 -6250 2120 -6260 {lab=rowon_n[8]}
N 2120 -6260 2320 -6260 {lab=rowon_n[8]}
N 2320 -6260 2330 -6250 {lab=rowon_n[8]}
N 2330 -6250 2460 -6250 {lab=rowon_n[8]}
N 2320 -6240 2330 -6230 {lab=#net15}
N 2330 -6230 2460 -6230 {lab=#net15}
N 2110 -6210 2120 -6220 {lab=#net16}
N 2120 -6220 2320 -6220 {lab=#net16}
N 2320 -6220 2330 -6210 {lab=#net16}
N 2330 -6210 2460 -6210 {lab=#net16}
N 2110 -6230 2120 -6240 {lab=#net15}
N 2120 -6240 2320 -6240 {lab=#net15}
N 2460 -6290 2470 -6300 {lab=rowoff_n[8]}
N 2470 -6300 2670 -6300 {lab=rowoff_n[8]}
N 2670 -6300 2680 -6290 {lab=rowoff_n[8]}
N 2680 -6290 2800 -6290 {lab=rowoff_n[8]}
N 2460 -6270 2470 -6280 {lab=row_n[8]}
N 2470 -6280 2670 -6280 {lab=row_n[8]}
N 2670 -6280 2680 -6270 {lab=row_n[8]}
N 2680 -6270 2800 -6270 {lab=row_n[8]}
N 2460 -6250 2470 -6260 {lab=rowon_n[8]}
N 2470 -6260 2670 -6260 {lab=rowon_n[8]}
N 2670 -6260 2680 -6250 {lab=rowon_n[8]}
N 2680 -6250 2800 -6250 {lab=rowon_n[8]}
N 2460 -6230 2470 -6240 {lab=#net15}
N 2470 -6240 2670 -6240 {lab=#net15}
N 2670 -6240 2680 -6230 {lab=#net15}
N 2680 -6230 2800 -6230 {lab=#net15}
N 2460 -6210 2470 -6220 {lab=#net16}
N 2470 -6220 2670 -6220 {lab=#net16}
N 2670 -6220 2680 -6210 {lab=#net16}
N 2680 -6210 2800 -6210 {lab=#net16}
N 2800 -6290 2810 -6300 {lab=rowoff_n[8]}
N 2810 -6300 3010 -6300 {lab=rowoff_n[8]}
N 3010 -6300 3020 -6290 {lab=rowoff_n[8]}
N 3020 -6290 3150 -6290 {lab=rowoff_n[8]}
N 2800 -6270 2810 -6280 {lab=row_n[8]}
N 2810 -6280 3010 -6280 {lab=row_n[8]}
N 3010 -6280 3020 -6270 {lab=row_n[8]}
N 3020 -6270 3150 -6270 {lab=row_n[8]}
N 2800 -6250 2810 -6260 {lab=rowon_n[8]}
N 2810 -6260 3010 -6260 {lab=rowon_n[8]}
N 3010 -6260 3020 -6250 {lab=rowon_n[8]}
N 3020 -6250 3150 -6250 {lab=rowon_n[8]}
N 2800 -6230 2810 -6240 {lab=#net15}
N 2810 -6240 3010 -6240 {lab=#net15}
N 2800 -6210 2810 -6220 {lab=#net16}
N 2810 -6220 3010 -6220 {lab=#net16}
N 3010 -6220 3020 -6210 {lab=#net16}
N 3020 -6210 3150 -6210 {lab=#net16}
N 3010 -6240 3020 -6230 {lab=#net15}
N 3020 -6230 3150 -6230 {lab=#net15}
N 3150 -6290 3160 -6300 {lab=rowoff_n[8]}
N 3160 -6300 3360 -6300 {lab=rowoff_n[8]}
N 3360 -6300 3370 -6290 {lab=rowoff_n[8]}
N 3370 -6290 3510 -6290 {lab=rowoff_n[8]}
N 3150 -6270 3160 -6280 {lab=row_n[8]}
N 3160 -6280 3360 -6280 {lab=row_n[8]}
N 3360 -6280 3370 -6270 {lab=row_n[8]}
N 3370 -6270 3510 -6270 {lab=row_n[8]}
N 3150 -6250 3160 -6260 {lab=rowon_n[8]}
N 3160 -6260 3360 -6260 {lab=rowon_n[8]}
N 3360 -6260 3370 -6250 {lab=rowon_n[8]}
N 3370 -6250 3510 -6250 {lab=rowon_n[8]}
N 3150 -6230 3160 -6240 {lab=#net15}
N 3160 -6240 3360 -6240 {lab=#net15}
N 3360 -6240 3370 -6230 {lab=#net15}
N 3370 -6230 3510 -6230 {lab=#net15}
N 3150 -6210 3160 -6220 {lab=#net16}
N 3160 -6220 3360 -6220 {lab=#net16}
N 3360 -6220 3370 -6210 {lab=#net16}
N 3370 -6210 3510 -6210 {lab=#net16}
N 3510 -6290 3520 -6300 {lab=rowoff_n[8]}
N 3520 -6300 3720 -6300 {lab=rowoff_n[8]}
N 3720 -6300 3730 -6290 {lab=rowoff_n[8]}
N 3730 -6290 3840 -6290 {lab=rowoff_n[8]}
N 3510 -6270 3520 -6280 {lab=row_n[8]}
N 3520 -6280 3720 -6280 {lab=row_n[8]}
N 3720 -6280 3730 -6270 {lab=row_n[8]}
N 3730 -6270 3840 -6270 {lab=row_n[8]}
N 3510 -6250 3520 -6260 {lab=rowon_n[8]}
N 3520 -6260 3720 -6260 {lab=rowon_n[8]}
N 3720 -6260 3730 -6250 {lab=rowon_n[8]}
N 3730 -6250 3840 -6250 {lab=rowon_n[8]}
N 3510 -6230 3520 -6240 {lab=#net15}
N 3520 -6240 3720 -6240 {lab=#net15}
N 3720 -6240 3730 -6230 {lab=#net15}
N 3730 -6230 3840 -6230 {lab=#net15}
N 3510 -6210 3520 -6220 {lab=#net16}
N 3520 -6220 3720 -6220 {lab=#net16}
N 3720 -6220 3730 -6210 {lab=#net16}
N 3730 -6210 3840 -6210 {lab=#net16}
N 3840 -6290 3850 -6300 {lab=rowoff_n[8]}
N 3850 -6300 4050 -6300 {lab=rowoff_n[8]}
N 4050 -6300 4060 -6290 {lab=rowoff_n[8]}
N 4060 -6290 4170 -6290 {lab=rowoff_n[8]}
N 3840 -6270 3850 -6280 {lab=row_n[8]}
N 3850 -6280 4050 -6280 {lab=row_n[8]}
N 4050 -6280 4060 -6270 {lab=row_n[8]}
N 4060 -6270 4170 -6270 {lab=row_n[8]}
N 3840 -6250 3850 -6260 {lab=rowon_n[8]}
N 3850 -6260 4050 -6260 {lab=rowon_n[8]}
N 4050 -6260 4060 -6250 {lab=rowon_n[8]}
N 4060 -6250 4170 -6250 {lab=rowon_n[8]}
N 3840 -6230 3850 -6240 {lab=#net15}
N 3850 -6240 4050 -6240 {lab=#net15}
N 4050 -6240 4060 -6230 {lab=#net15}
N 4060 -6230 4170 -6230 {lab=#net15}
N 3840 -6210 3850 -6220 {lab=#net16}
N 3850 -6220 4050 -6220 {lab=#net16}
N 4050 -6220 4070 -6210 {lab=#net16}
N 4070 -6210 4170 -6210 {lab=#net16}
N 4170 -6290 4180 -6300 {lab=rowoff_n[8]}
N 4180 -6300 4380 -6300 {lab=rowoff_n[8]}
N 4380 -6300 4390 -6290 {lab=rowoff_n[8]}
N 4390 -6290 4520 -6290 {lab=rowoff_n[8]}
N 4170 -6270 4180 -6280 {lab=row_n[8]}
N 4180 -6280 4380 -6280 {lab=row_n[8]}
N 4380 -6280 4390 -6270 {lab=row_n[8]}
N 4390 -6270 4520 -6270 {lab=row_n[8]}
N 4170 -6250 4180 -6260 {lab=rowon_n[8]}
N 4180 -6260 4380 -6260 {lab=rowon_n[8]}
N 4380 -6260 4390 -6250 {lab=rowon_n[8]}
N 4390 -6250 4520 -6250 {lab=rowon_n[8]}
N 4170 -6230 4180 -6240 {lab=#net15}
N 4180 -6240 4380 -6240 {lab=#net15}
N 4380 -6240 4390 -6230 {lab=#net15}
N 4390 -6230 4520 -6230 {lab=#net15}
N 4170 -6210 4180 -6220 {lab=#net16}
N 4180 -6220 4380 -6220 {lab=#net16}
N 4380 -6220 4390 -6210 {lab=#net16}
N 4390 -6210 4520 -6210 {lab=#net16}
N 4520 -6290 4530 -6300 {lab=rowoff_n[8]}
N 4530 -6300 4730 -6300 {lab=rowoff_n[8]}
N 4730 -6300 4740 -6290 {lab=rowoff_n[8]}
N 4740 -6290 4870 -6290 {lab=rowoff_n[8]}
N 4520 -6270 4530 -6280 {lab=row_n[8]}
N 4530 -6280 4730 -6280 {lab=row_n[8]}
N 4520 -6250 4530 -6260 {lab=rowon_n[8]}
N 4530 -6260 4730 -6260 {lab=rowon_n[8]}
N 4730 -6260 4740 -6250 {lab=rowon_n[8]}
N 4740 -6250 4870 -6250 {lab=rowon_n[8]}
N 4730 -6280 4740 -6270 {lab=row_n[8]}
N 4740 -6270 4870 -6270 {lab=row_n[8]}
N 4520 -6230 4530 -6240 {lab=#net15}
N 4530 -6240 4730 -6240 {lab=#net15}
N 4730 -6240 4740 -6230 {lab=#net15}
N 4740 -6230 4870 -6230 {lab=#net15}
N 4520 -6210 4530 -6220 {lab=#net16}
N 4530 -6220 4730 -6220 {lab=#net16}
N 4730 -6220 4740 -6210 {lab=#net16}
N 4740 -6210 4870 -6210 {lab=#net16}
N 4870 -6290 4880 -6300 {lab=rowoff_n[8]}
N 4880 -6300 5080 -6300 {lab=rowoff_n[8]}
N 5080 -6300 5090 -6290 {lab=rowoff_n[8]}
N 5090 -6290 5210 -6290 {lab=rowoff_n[8]}
N 4870 -6270 4880 -6280 {lab=row_n[8]}
N 4880 -6280 5080 -6280 {lab=row_n[8]}
N 5080 -6280 5090 -6270 {lab=row_n[8]}
N 5090 -6270 5210 -6270 {lab=row_n[8]}
N 4870 -6250 4880 -6260 {lab=rowon_n[8]}
N 4880 -6260 5080 -6260 {lab=rowon_n[8]}
N 5080 -6260 5090 -6250 {lab=rowon_n[8]}
N 5090 -6250 5210 -6250 {lab=rowon_n[8]}
N 4870 -6230 4880 -6240 {lab=#net15}
N 4880 -6240 5080 -6240 {lab=#net15}
N 5080 -6240 5090 -6230 {lab=#net15}
N 5090 -6230 5210 -6230 {lab=#net15}
N 4870 -6210 4880 -6220 {lab=#net16}
N 4880 -6220 5080 -6220 {lab=#net16}
N 5080 -6220 5090 -6210 {lab=#net16}
N 5090 -6210 5210 -6210 {lab=#net16}
N 5210 -6290 5220 -6300 {lab=rowoff_n[8]}
N 5220 -6300 5420 -6300 {lab=rowoff_n[8]}
N 5420 -6300 5430 -6290 {lab=rowoff_n[8]}
N 5430 -6290 5550 -6290 {lab=rowoff_n[8]}
N 5210 -6270 5220 -6280 {lab=row_n[8]}
N 5220 -6280 5420 -6280 {lab=row_n[8]}
N 5420 -6280 5430 -6270 {lab=row_n[8]}
N 5430 -6270 5550 -6270 {lab=row_n[8]}
N 5210 -6250 5220 -6260 {lab=rowon_n[8]}
N 5220 -6260 5420 -6260 {lab=rowon_n[8]}
N 5420 -6260 5430 -6250 {lab=rowon_n[8]}
N 5430 -6250 5550 -6250 {lab=rowon_n[8]}
N 5210 -6230 5220 -6240 {lab=#net15}
N 5220 -6240 5420 -6240 {lab=#net15}
N 5420 -6240 5430 -6230 {lab=#net15}
N 5430 -6230 5550 -6230 {lab=#net15}
N 5210 -6210 5220 -6220 {lab=#net16}
N 5220 -6220 5420 -6220 {lab=#net16}
N 5420 -6220 5440 -6210 {lab=#net16}
N 5440 -6210 5550 -6210 {lab=#net16}
N 5550 -6290 5560 -6300 {lab=rowoff_n[8]}
N 5560 -6300 5760 -6300 {lab=rowoff_n[8]}
N 5550 -6270 5560 -6280 {lab=row_n[8]}
N 5560 -6280 5760 -6280 {lab=row_n[8]}
N 5760 -6280 5770 -6270 {lab=row_n[8]}
N 5760 -6300 5770 -6290 {lab=rowoff_n[8]}
N 5550 -6250 5560 -6260 {lab=rowon_n[8]}
N 5560 -6260 5760 -6260 {lab=rowon_n[8]}
N 5550 -6230 5560 -6240 {lab=#net15}
N 5560 -6240 5760 -6240 {lab=#net15}
N 5760 -6240 5770 -6230 {lab=#net15}
N 5550 -6210 5560 -6220 {lab=#net16}
N 5560 -6220 5760 -6220 {lab=#net16}
N 5760 -6220 5770 -6210 {lab=#net16}
N 5760 -6260 5770 -6250 {lab=rowon_n[8]}
N 880 -5800 890 -5810 {lab=VDD}
N 890 -6060 890 -5810 {lab=VDD}
N 880 -6070 890 -6060 {lab=VDD}
N 880 -6130 880 -6070 {lab=VDD}
N 900 -6130 900 -6070 {lab=VSS}
N 900 -6070 910 -6060 {lab=VSS}
N 910 -6060 910 -5810 {lab=VSS}
N 900 -5800 910 -5810 {lab=VSS}
N 1210 -6060 1210 -5810 {lab=col_n[0]}
N 1200 -6070 1210 -6060 {lab=col_n[0]}
N 1200 -6130 1200 -6070 {lab=col_n[0]}
N 1220 -6130 1220 -6070 {lab=col[0]}
N 1220 -6070 1230 -6060 {lab=col[0]}
N 1230 -6060 1230 -5810 {lab=col[0]}
N 1540 -6060 1540 -5810 {lab=col_n[1]}
N 1530 -6070 1540 -6060 {lab=col_n[1]}
N 1530 -6130 1530 -6070 {lab=col_n[1]}
N 1550 -6130 1550 -6070 {lab=col[1]}
N 1550 -6070 1560 -6060 {lab=col[1]}
N 1560 -6060 1560 -5810 {lab=col[1]}
N 1890 -6060 1890 -5810 {lab=col_n[2]}
N 1880 -6070 1890 -6060 {lab=col_n[2]}
N 1880 -6130 1880 -6070 {lab=col_n[2]}
N 1900 -6130 1900 -6070 {lab=col[2]}
N 1900 -6070 1910 -6060 {lab=col[2]}
N 1910 -6060 1910 -5810 {lab=col[2]}
N 2240 -6060 2240 -5810 {lab=col_n[3]}
N 2230 -6070 2240 -6060 {lab=col_n[3]}
N 2230 -6130 2230 -6070 {lab=col_n[3]}
N 2250 -6130 2250 -6070 {lab=col[3]}
N 2250 -6070 2260 -6060 {lab=col[3]}
N 2260 -6060 2260 -5810 {lab=col[3]}
N 2590 -6060 2590 -5810 {lab=col_n[4]}
N 2580 -6070 2590 -6060 {lab=col_n[4]}
N 2580 -6130 2580 -6070 {lab=col_n[4]}
N 2600 -6130 2600 -6070 {lab=col[4]}
N 2600 -6070 2610 -6060 {lab=col[4]}
N 2610 -6060 2610 -5810 {lab=col[4]}
N 2930 -6060 2930 -5810 {lab=col_n[5]}
N 2920 -6070 2930 -6060 {lab=col_n[5]}
N 2920 -6130 2920 -6070 {lab=col_n[5]}
N 2940 -6130 2940 -6070 {lab=col[5]}
N 2940 -6070 2950 -6060 {lab=col[5]}
N 2950 -6060 2950 -5810 {lab=col[5]}
N 3280 -6060 3280 -5810 {lab=col_n[6]}
N 3270 -6070 3280 -6060 {lab=col_n[6]}
N 3270 -6130 3270 -6070 {lab=col_n[6]}
N 3290 -6130 3290 -6070 {lab=col[6]}
N 3290 -6070 3300 -6060 {lab=col[6]}
N 3300 -6060 3300 -5810 {lab=col[6]}
N 3640 -6060 3640 -5810 {lab=col_n[7]}
N 3630 -6070 3640 -6060 {lab=col_n[7]}
N 3630 -6130 3630 -6070 {lab=col_n[7]}
N 3650 -6130 3650 -6070 {lab=col[7]}
N 3650 -6070 3660 -6060 {lab=col[7]}
N 3660 -6060 3660 -5810 {lab=col[7]}
N 3970 -6060 3970 -5810 {lab=col_n[8]}
N 3960 -6070 3970 -6060 {lab=col_n[8]}
N 3960 -6130 3960 -6070 {lab=col_n[8]}
N 3980 -6130 3980 -6070 {lab=col[8]}
N 3980 -6070 3990 -6060 {lab=col[8]}
N 3990 -6060 3990 -5810 {lab=col[8]}
N 4300 -6060 4300 -5810 {lab=col_n[9]}
N 4290 -6070 4300 -6060 {lab=col_n[9]}
N 4290 -6130 4290 -6070 {lab=col_n[9]}
N 4310 -6130 4310 -6070 {lab=col[9]}
N 4310 -6070 4320 -6060 {lab=col[9]}
N 4320 -6060 4320 -5810 {lab=col[9]}
N 4650 -6060 4650 -5810 {lab=col_n[10]}
N 4640 -6070 4650 -6060 {lab=col_n[10]}
N 4640 -6130 4640 -6070 {lab=col_n[10]}
N 4660 -6130 4660 -6070 {lab=col[10]}
N 4660 -6070 4670 -6060 {lab=col[10]}
N 4670 -6060 4670 -5810 {lab=col[10]}
N 5000 -6060 5000 -5810 {lab=col_n[11]}
N 4990 -6070 5000 -6060 {lab=col_n[11]}
N 4990 -6130 4990 -6070 {lab=col_n[11]}
N 5010 -6130 5010 -6070 {lab=col[11]}
N 5010 -6070 5020 -6060 {lab=col[11]}
N 5020 -6060 5020 -5810 {lab=col[11]}
N 5340 -6060 5340 -5810 {lab=col_n[12]}
N 5330 -6070 5340 -6060 {lab=col_n[12]}
N 5330 -6130 5330 -6070 {lab=col_n[12]}
N 5350 -6130 5350 -6070 {lab=col[12]}
N 5350 -6070 5360 -6060 {lab=col[12]}
N 5360 -6060 5360 -5810 {lab=col[12]}
N 5680 -6060 5680 -5810 {lab=VDD}
N 5670 -6070 5680 -6060 {lab=VDD}
N 5670 -6130 5670 -6070 {lab=VDD}
N 5690 -6130 5690 -6070 {lab=VSS}
N 5690 -6070 5700 -6060 {lab=VSS}
N 5700 -6060 5700 -5810 {lab=VSS}
N 5690 -5800 5700 -5810 {lab=VSS}
N 5670 -5800 5680 -5810 {lab=VDD}
N 5330 -5800 5340 -5810 {lab=col_n[12]}
N 5350 -5800 5360 -5810 {lab=col[12]}
N 4990 -5800 5000 -5810 {lab=col_n[11]}
N 5010 -5800 5020 -5810 {lab=col[11]}
N 4640 -5800 4650 -5810 {lab=col_n[10]}
N 4660 -5800 4670 -5810 {lab=col[10]}
N 4310 -5800 4320 -5810 {lab=col[9]}
N 4290 -5800 4300 -5810 {lab=col_n[9]}
N 3980 -5800 3990 -5810 {lab=col[8]}
N 3960 -5800 3970 -5810 {lab=col_n[8]}
N 3630 -5800 3640 -5810 {lab=col_n[7]}
N 3650 -5800 3660 -5810 {lab=col[7]}
N 3270 -5800 3280 -5810 {lab=col_n[6]}
N 3290 -5800 3300 -5810 {lab=col[6]}
N 2940 -5800 2950 -5810 {lab=col[5]}
N 2920 -5800 2930 -5810 {lab=col_n[5]}
N 2600 -5800 2610 -5810 {lab=col[4]}
N 2580 -5800 2590 -5810 {lab=col_n[4]}
N 2250 -5800 2260 -5810 {lab=col[3]}
N 2230 -5800 2240 -5810 {lab=col_n[3]}
N 1900 -5800 1910 -5810 {lab=col[2]}
N 1880 -5800 1890 -5810 {lab=col_n[2]}
N 1550 -5800 1560 -5810 {lab=col[1]}
N 1530 -5800 1540 -5810 {lab=col_n[1]}
N 1200 -5800 1210 -5810 {lab=col_n[0]}
N 1220 -5800 1230 -5810 {lab=col[0]}
N 880 -5800 880 -5760 {lab=VDD}
N 900 -5800 900 -5760 {lab=VSS}
N 880 -5480 890 -5490 {lab=VDD}
N 890 -5750 890 -5490 {lab=VDD}
N 880 -5760 890 -5750 {lab=VDD}
N 900 -5760 910 -5750 {lab=VSS}
N 910 -5750 910 -5490 {lab=VSS}
N 900 -5480 910 -5490 {lab=VSS}
N 1200 -5800 1200 -5760 {lab=col_n[0]}
N 1220 -5800 1220 -5760 {lab=col[0]}
N 1210 -5750 1210 -5490 {lab=col_n[0]}
N 1200 -5760 1210 -5750 {lab=col_n[0]}
N 1220 -5760 1230 -5750 {lab=col[0]}
N 1230 -5750 1230 -5490 {lab=col[0]}
N 1530 -5800 1530 -5760 {lab=col_n[1]}
N 1550 -5800 1550 -5760 {lab=col[1]}
N 1540 -5750 1540 -5490 {lab=col_n[1]}
N 1530 -5760 1540 -5750 {lab=col_n[1]}
N 1550 -5760 1560 -5750 {lab=col[1]}
N 1560 -5750 1560 -5490 {lab=col[1]}
N 1880 -5800 1880 -5760 {lab=col_n[2]}
N 1900 -5800 1900 -5760 {lab=col[2]}
N 1890 -5750 1890 -5490 {lab=col_n[2]}
N 1880 -5760 1890 -5750 {lab=col_n[2]}
N 1900 -5760 1910 -5750 {lab=col[2]}
N 1910 -5750 1910 -5490 {lab=col[2]}
N 2230 -5800 2230 -5760 {lab=col_n[3]}
N 2250 -5800 2250 -5760 {lab=col[3]}
N 2240 -5750 2240 -5490 {lab=col_n[3]}
N 2230 -5760 2240 -5750 {lab=col_n[3]}
N 2250 -5760 2260 -5750 {lab=col[3]}
N 2260 -5750 2260 -5490 {lab=col[3]}
N 2580 -5800 2580 -5760 {lab=col_n[4]}
N 2600 -5800 2600 -5760 {lab=col[4]}
N 2590 -5750 2590 -5490 {lab=col_n[4]}
N 2580 -5760 2590 -5750 {lab=col_n[4]}
N 2600 -5760 2610 -5750 {lab=col[4]}
N 2610 -5750 2610 -5490 {lab=col[4]}
N 2920 -5800 2920 -5760 {lab=col_n[5]}
N 2940 -5800 2940 -5760 {lab=col[5]}
N 2930 -5750 2930 -5490 {lab=col_n[5]}
N 2920 -5760 2930 -5750 {lab=col_n[5]}
N 2940 -5760 2950 -5750 {lab=col[5]}
N 2950 -5750 2950 -5490 {lab=col[5]}
N 3270 -5800 3270 -5760 {lab=col_n[6]}
N 3290 -5800 3290 -5760 {lab=col[6]}
N 3280 -5750 3280 -5490 {lab=col_n[6]}
N 3270 -5760 3280 -5750 {lab=col_n[6]}
N 3290 -5760 3300 -5750 {lab=col[6]}
N 3300 -5750 3300 -5490 {lab=col[6]}
N 3630 -5800 3630 -5760 {lab=col_n[7]}
N 3650 -5800 3650 -5760 {lab=col[7]}
N 3640 -5750 3640 -5490 {lab=col_n[7]}
N 3630 -5760 3640 -5750 {lab=col_n[7]}
N 3650 -5760 3660 -5750 {lab=col[7]}
N 3660 -5750 3660 -5490 {lab=col[7]}
N 3960 -5800 3960 -5760 {lab=col_n[8]}
N 3980 -5800 3980 -5760 {lab=col[8]}
N 3970 -5750 3970 -5490 {lab=col_n[8]}
N 3960 -5760 3970 -5750 {lab=col_n[8]}
N 3980 -5760 3990 -5750 {lab=col[8]}
N 3990 -5750 3990 -5490 {lab=col[8]}
N 4640 -5800 4640 -5760 {lab=col_n[10]}
N 4660 -5800 4660 -5760 {lab=col[10]}
N 4650 -5750 4650 -5490 {lab=col_n[10]}
N 4640 -5760 4650 -5750 {lab=col_n[10]}
N 4660 -5760 4670 -5750 {lab=col[10]}
N 4670 -5750 4670 -5490 {lab=col[10]}
N 4990 -5800 4990 -5760 {lab=col_n[11]}
N 5010 -5800 5010 -5760 {lab=col[11]}
N 5000 -5750 5000 -5490 {lab=col_n[11]}
N 4990 -5760 5000 -5750 {lab=col_n[11]}
N 5010 -5760 5020 -5750 {lab=col[11]}
N 5020 -5750 5020 -5490 {lab=col[11]}
N 5330 -5800 5330 -5760 {lab=col_n[12]}
N 5350 -5800 5350 -5760 {lab=col[12]}
N 5340 -5750 5340 -5490 {lab=col_n[12]}
N 5330 -5760 5340 -5750 {lab=col_n[12]}
N 5350 -5760 5360 -5750 {lab=col[12]}
N 5360 -5750 5360 -5490 {lab=col[12]}
N 5670 -5800 5670 -5760 {lab=VDD}
N 5690 -5800 5690 -5760 {lab=VSS}
N 5680 -5750 5680 -5490 {lab=VDD}
N 5670 -5760 5680 -5750 {lab=VDD}
N 5690 -5760 5700 -5750 {lab=VSS}
N 5700 -5750 5700 -5490 {lab=VSS}
N 5690 -5480 5700 -5490 {lab=VSS}
N 5670 -5480 5680 -5490 {lab=VDD}
N 5350 -5480 5360 -5490 {lab=col[12]}
N 5330 -5480 5340 -5490 {lab=col_n[12]}
N 5010 -5480 5020 -5490 {lab=col[11]}
N 4990 -5480 5000 -5490 {lab=col_n[11]}
N 4660 -5480 4670 -5490 {lab=col[10]}
N 4640 -5480 4650 -5490 {lab=col_n[10]}
N 4290 -5800 4290 -5760 {lab=col_n[9]}
N 4310 -5800 4310 -5760 {lab=col[9]}
N 4300 -5750 4300 -5490 {lab=col_n[9]}
N 4290 -5760 4300 -5750 {lab=col_n[9]}
N 4310 -5760 4320 -5750 {lab=col[9]}
N 4320 -5750 4320 -5490 {lab=col[9]}
N 4310 -5480 4320 -5490 {lab=col[9]}
N 4290 -5480 4300 -5490 {lab=col_n[9]}
N 3980 -5480 3990 -5490 {lab=col[8]}
N 3960 -5480 3970 -5490 {lab=col_n[8]}
N 3650 -5480 3660 -5490 {lab=col[7]}
N 3630 -5480 3640 -5490 {lab=col_n[7]}
N 3290 -5480 3300 -5490 {lab=col[6]}
N 3270 -5480 3280 -5490 {lab=col_n[6]}
N 2940 -5480 2950 -5490 {lab=col[5]}
N 2920 -5480 2930 -5490 {lab=col_n[5]}
N 2600 -5480 2610 -5490 {lab=col[4]}
N 2580 -5480 2590 -5490 {lab=col_n[4]}
N 1200 -5480 1210 -5490 {lab=col_n[0]}
N 1220 -5480 1230 -5490 {lab=col[0]}
N 1530 -5480 1540 -5490 {lab=col_n[1]}
N 1550 -5480 1560 -5490 {lab=col[1]}
N 1880 -5480 1890 -5490 {lab=col_n[2]}
N 1900 -5480 1910 -5490 {lab=col[2]}
N 2230 -5480 2240 -5490 {lab=col_n[3]}
N 2250 -5480 2260 -5490 {lab=col[3]}
N 880 -4800 890 -4810 {lab=VDD}
N 890 -5100 890 -4810 {lab=VDD}
N 880 -5110 890 -5100 {lab=VDD}
N 900 -4800 910 -4810 {lab=VSS}
N 910 -5100 910 -4810 {lab=VSS}
N 900 -5110 910 -5100 {lab=VSS}
N 1200 -5150 1200 -5110 {lab=col_n[0]}
N 1220 -5150 1220 -5110 {lab=col[0]}
N 1210 -5100 1210 -4810 {lab=col_n[0]}
N 1200 -5110 1210 -5100 {lab=col_n[0]}
N 1230 -5100 1230 -4810 {lab=col[0]}
N 1220 -5110 1230 -5100 {lab=col[0]}
N 1530 -5150 1530 -5110 {lab=col_n[1]}
N 1550 -5150 1550 -5110 {lab=col[1]}
N 1540 -5100 1540 -4810 {lab=col_n[1]}
N 1530 -5110 1540 -5100 {lab=col_n[1]}
N 1560 -5100 1560 -4810 {lab=col[1]}
N 1550 -5110 1560 -5100 {lab=col[1]}
N 1880 -5150 1880 -5110 {lab=col_n[2]}
N 1900 -5150 1900 -5110 {lab=col[2]}
N 1890 -5100 1890 -4810 {lab=col_n[2]}
N 1880 -5110 1890 -5100 {lab=col_n[2]}
N 1910 -5100 1910 -4810 {lab=col[2]}
N 1900 -5110 1910 -5100 {lab=col[2]}
N 2230 -5150 2230 -5110 {lab=col_n[3]}
N 2250 -5150 2250 -5110 {lab=col[3]}
N 2240 -5100 2240 -4810 {lab=col_n[3]}
N 2230 -5110 2240 -5100 {lab=col_n[3]}
N 2260 -5100 2260 -4810 {lab=col[3]}
N 2250 -5110 2260 -5100 {lab=col[3]}
N 2580 -5150 2580 -5110 {lab=col_n[4]}
N 2600 -5150 2600 -5110 {lab=col[4]}
N 2590 -5100 2590 -4810 {lab=col_n[4]}
N 2580 -5110 2590 -5100 {lab=col_n[4]}
N 2610 -5100 2610 -4810 {lab=col[4]}
N 2600 -5110 2610 -5100 {lab=col[4]}
N 2920 -5150 2920 -5110 {lab=col_n[5]}
N 2940 -5150 2940 -5110 {lab=col[5]}
N 2930 -5100 2930 -4810 {lab=col_n[5]}
N 2920 -5110 2930 -5100 {lab=col_n[5]}
N 2950 -5100 2950 -4810 {lab=col[5]}
N 2940 -5110 2950 -5100 {lab=col[5]}
N 3270 -5150 3270 -5110 {lab=col_n[6]}
N 3290 -5150 3290 -5110 {lab=col[6]}
N 3280 -5100 3280 -4810 {lab=col_n[6]}
N 3270 -5110 3280 -5100 {lab=col_n[6]}
N 3300 -5100 3300 -4810 {lab=col[6]}
N 3290 -5110 3300 -5100 {lab=col[6]}
N 3630 -5150 3630 -5110 {lab=col_n[7]}
N 3650 -5150 3650 -5110 {lab=col[7]}
N 3640 -5100 3640 -4810 {lab=col_n[7]}
N 3630 -5110 3640 -5100 {lab=col_n[7]}
N 3660 -5100 3660 -4810 {lab=col[7]}
N 3650 -5110 3660 -5100 {lab=col[7]}
N 3960 -5150 3960 -5110 {lab=col_n[8]}
N 3980 -5150 3980 -5110 {lab=col[8]}
N 3970 -5100 3970 -4810 {lab=col_n[8]}
N 3960 -5110 3970 -5100 {lab=col_n[8]}
N 3990 -5100 3990 -4810 {lab=col[8]}
N 3980 -5110 3990 -5100 {lab=col[8]}
N 4290 -5150 4290 -5110 {lab=col_n[9]}
N 4310 -5150 4310 -5110 {lab=col[9]}
N 4300 -5100 4300 -4810 {lab=col_n[9]}
N 4290 -5110 4300 -5100 {lab=col_n[9]}
N 4320 -5100 4320 -4810 {lab=col[9]}
N 4310 -5110 4320 -5100 {lab=col[9]}
N 4640 -5150 4640 -5110 {lab=col_n[10]}
N 4660 -5150 4660 -5110 {lab=col[10]}
N 4650 -5100 4650 -4810 {lab=col_n[10]}
N 4640 -5110 4650 -5100 {lab=col_n[10]}
N 4670 -5100 4670 -4810 {lab=col[10]}
N 4660 -5110 4670 -5100 {lab=col[10]}
N 4990 -5150 4990 -5110 {lab=col_n[11]}
N 5010 -5150 5010 -5110 {lab=col[11]}
N 5000 -5100 5000 -4810 {lab=col_n[11]}
N 4990 -5110 5000 -5100 {lab=col_n[11]}
N 5020 -5100 5020 -4810 {lab=col[11]}
N 5010 -5110 5020 -5100 {lab=col[11]}
N 5330 -5150 5330 -5110 {lab=col_n[12]}
N 5350 -5150 5350 -5110 {lab=col[12]}
N 5340 -5100 5340 -4810 {lab=col_n[12]}
N 5330 -5110 5340 -5100 {lab=col_n[12]}
N 5360 -5100 5360 -4810 {lab=col[12]}
N 5350 -5110 5360 -5100 {lab=col[12]}
N 5670 -5150 5670 -5110 {lab=VDD}
N 5690 -5150 5690 -5110 {lab=VSS}
N 5680 -5100 5680 -4810 {lab=VDD}
N 5670 -5110 5680 -5100 {lab=VDD}
N 5700 -5100 5700 -4810 {lab=VSS}
N 5690 -5110 5700 -5100 {lab=VSS}
N 1200 -4800 1210 -4810 {lab=col_n[0]}
N 1220 -4800 1230 -4810 {lab=col[0]}
N 1530 -4800 1540 -4810 {lab=col_n[1]}
N 1550 -4800 1560 -4810 {lab=col[1]}
N 1880 -4800 1890 -4810 {lab=col_n[2]}
N 1900 -4800 1910 -4810 {lab=col[2]}
N 2230 -4800 2240 -4810 {lab=col_n[3]}
N 2250 -4800 2260 -4810 {lab=col[3]}
N 2580 -4800 2590 -4810 {lab=col_n[4]}
N 2600 -4800 2610 -4810 {lab=col[4]}
N 2920 -4800 2930 -4810 {lab=col_n[5]}
N 2940 -4800 2950 -4810 {lab=col[5]}
N 3630 -4800 3640 -4810 {lab=col_n[7]}
N 3650 -4800 3660 -4810 {lab=col[7]}
N 3270 -4800 3280 -4810 {lab=col_n[6]}
N 3290 -4800 3300 -4810 {lab=col[6]}
N 3960 -4800 3970 -4810 {lab=col_n[8]}
N 3980 -4800 3990 -4810 {lab=col[8]}
N 4310 -4800 4320 -4810 {lab=col[9]}
N 4290 -4800 4300 -4810 {lab=col_n[9]}
N 4640 -4800 4650 -4810 {lab=col_n[10]}
N 4660 -4800 4670 -4810 {lab=col[10]}
N 4990 -4800 5000 -4810 {lab=col_n[11]}
N 5010 -4800 5020 -4810 {lab=col[11]}
N 5330 -4800 5340 -4810 {lab=col_n[12]}
N 5350 -4800 5360 -4810 {lab=col[12]}
N 5670 -4800 5680 -4810 {lab=VDD}
N 5690 -4800 5700 -4810 {lab=VSS}
N 800 -6440 800 -6430 {
lab=VSS}
N 1120 -6440 1120 -6430 {
lab=VSS}
N 1450 -6440 1450 -6430 {
lab=VSS}
N 1800 -6440 1800 -6430 {
lab=VSS}
N 2150 -6440 2150 -6430 {
lab=VSS}
N 2500 -6440 2500 -6430 {
lab=VSS}
N 2840 -6440 2840 -6430 {
lab=VSS}
N 3190 -6440 3190 -6430 {
lab=VSS}
N 3550 -6440 3550 -6430 {
lab=VSS}
N 3880 -6440 3880 -6430 {
lab=VSS}
N 4210 -6440 4210 -6430 {
lab=VSS}
N 4560 -6440 4560 -6430 {
lab=VSS}
N 4910 -6440 4910 -6430 {
lab=VSS}
N 5250 -6440 5250 -6430 {
lab=VSS}
N 5590 -6440 5590 -6430 {
lab=VSS}
N 5610 -6680 5610 -6660 {
lab=vcm}
N 5590 -6670 5590 -6660 {
lab=VDD}
N 5650 -6680 5650 -6660 {
lab=ctop}
N 4930 -6680 4930 -6660 {
lab=vcm}
N 4910 -6670 4910 -6660 {
lab=VDD}
N 4970 -6680 4970 -6660 {
lab=ctop}
N 5270 -6680 5270 -6660 {
lab=vcm}
N 5250 -6670 5250 -6660 {
lab=VDD}
N 5310 -6680 5310 -6660 {
lab=ctop}
N 4580 -6680 4580 -6660 {
lab=vcm}
N 4560 -6670 4560 -6660 {
lab=VDD}
N 4620 -6680 4620 -6660 {
lab=ctop}
N 4230 -6680 4230 -6660 {
lab=vcm}
N 4210 -6670 4210 -6660 {
lab=VDD}
N 4270 -6680 4270 -6660 {
lab=ctop}
N 3900 -6680 3900 -6660 {
lab=vcm}
N 3880 -6670 3880 -6660 {
lab=VDD}
N 3940 -6680 3940 -6660 {
lab=ctop}
N 3570 -6680 3570 -6660 {
lab=vcm}
N 3550 -6670 3550 -6660 {
lab=VDD}
N 3610 -6680 3610 -6660 {
lab=ctop}
N 3210 -6680 3210 -6660 {
lab=vcm}
N 3190 -6670 3190 -6660 {
lab=VDD}
N 3250 -6680 3250 -6660 {
lab=ctop}
N 2860 -6680 2860 -6660 {
lab=vcm}
N 2840 -6670 2840 -6660 {
lab=VDD}
N 2900 -6680 2900 -6660 {
lab=ctop}
N 2520 -6680 2520 -6660 {
lab=vcm}
N 2500 -6670 2500 -6660 {
lab=VDD}
N 2560 -6680 2560 -6660 {
lab=ctop}
N 2170 -6680 2170 -6660 {
lab=vcm}
N 2150 -6670 2150 -6660 {
lab=VDD}
N 2210 -6680 2210 -6660 {
lab=ctop}
N 1820 -6680 1820 -6660 {
lab=vcm}
N 1800 -6670 1800 -6660 {
lab=VDD}
N 1860 -6680 1860 -6660 {
lab=ctop}
N 1470 -6680 1470 -6660 {
lab=vcm}
N 1450 -6670 1450 -6660 {
lab=VDD}
N 1510 -6680 1510 -6660 {
lab=ctop}
N 1140 -6680 1140 -6660 {
lab=vcm}
N 1120 -6670 1120 -6660 {
lab=VDD}
N 1180 -6680 1180 -6660 {
lab=ctop}
N 820 -6680 820 -6660 {
lab=vcm}
N 800 -6670 800 -6660 {
lab=VDD}
N 860 -6680 860 -6660 {
lab=ctop}
N 740 -6520 760 -6520 {
lab=sample_n}
N 740 -6540 760 -6540 {
lab=sample}
N 740 -6560 760 -6560 {
lab=rowon_n[9]}
N 740 -6580 760 -6580 {
lab=row_n[9]}
N 740 -6600 760 -6600 {
lab=rowoff_n[9]}
N 980 -6540 1080 -6540 {lab=#net17}
N 980 -6520 1080 -6520 {lab=#net18}
N 760 -6600 770 -6610 {lab=rowoff_n[9]}
N 770 -6610 990 -6610 {lab=rowoff_n[9]}
N 990 -6610 1000 -6600 {lab=rowoff_n[9]}
N 1000 -6600 1080 -6600 {lab=rowoff_n[9]}
N 760 -6580 770 -6590 {lab=row_n[9]}
N 770 -6590 990 -6590 {lab=row_n[9]}
N 990 -6590 1000 -6580 {lab=row_n[9]}
N 1000 -6580 1080 -6580 {lab=row_n[9]}
N 760 -6560 770 -6570 {lab=rowon_n[9]}
N 770 -6570 990 -6570 {lab=rowon_n[9]}
N 990 -6570 1000 -6560 {lab=rowon_n[9]}
N 1000 -6560 1080 -6560 {lab=rowon_n[9]}
N 1080 -6600 1090 -6610 {lab=rowoff_n[9]}
N 1080 -6580 1090 -6590 {lab=row_n[9]}
N 1090 -6590 1290 -6590 {lab=row_n[9]}
N 1290 -6590 1300 -6580 {lab=row_n[9]}
N 1300 -6580 1410 -6580 {lab=row_n[9]}
N 1090 -6610 1290 -6610 {lab=rowoff_n[9]}
N 1290 -6610 1300 -6600 {lab=rowoff_n[9]}
N 1300 -6600 1410 -6600 {lab=rowoff_n[9]}
N 1080 -6560 1090 -6570 {lab=rowon_n[9]}
N 1090 -6570 1290 -6570 {lab=rowon_n[9]}
N 1290 -6570 1300 -6560 {lab=rowon_n[9]}
N 1300 -6560 1410 -6560 {lab=rowon_n[9]}
N 1080 -6540 1090 -6550 {lab=#net17}
N 1090 -6550 1290 -6550 {lab=#net17}
N 1290 -6550 1300 -6540 {lab=#net17}
N 1300 -6540 1410 -6540 {lab=#net17}
N 1080 -6520 1090 -6530 {lab=#net18}
N 1090 -6530 1290 -6530 {lab=#net18}
N 1290 -6530 1300 -6520 {lab=#net18}
N 1300 -6520 1410 -6520 {lab=#net18}
N 1410 -6580 1420 -6590 {lab=row_n[9]}
N 1420 -6590 1620 -6590 {lab=row_n[9]}
N 1620 -6590 1630 -6580 {lab=row_n[9]}
N 1630 -6580 1760 -6580 {lab=row_n[9]}
N 1410 -6560 1420 -6570 {lab=rowon_n[9]}
N 1420 -6570 1620 -6570 {lab=rowon_n[9]}
N 1620 -6570 1630 -6560 {lab=rowon_n[9]}
N 1630 -6560 1760 -6560 {lab=rowon_n[9]}
N 1410 -6540 1420 -6550 {lab=#net17}
N 1420 -6550 1620 -6550 {lab=#net17}
N 1620 -6550 1630 -6540 {lab=#net17}
N 1630 -6540 1760 -6540 {lab=#net17}
N 1410 -6520 1430 -6530 {lab=#net18}
N 1430 -6530 1620 -6530 {lab=#net18}
N 1620 -6530 1630 -6520 {lab=#net18}
N 1630 -6520 1760 -6520 {lab=#net18}
N 1410 -6600 1420 -6610 {lab=rowoff_n[9]}
N 1420 -6610 1620 -6610 {lab=rowoff_n[9]}
N 1620 -6610 1630 -6600 {lab=rowoff_n[9]}
N 1630 -6600 1760 -6600 {lab=rowoff_n[9]}
N 1760 -6600 1770 -6610 {lab=rowoff_n[9]}
N 1770 -6610 1970 -6610 {lab=rowoff_n[9]}
N 1970 -6610 1980 -6600 {lab=rowoff_n[9]}
N 1980 -6600 2110 -6600 {lab=rowoff_n[9]}
N 1760 -6580 1770 -6590 {lab=row_n[9]}
N 1770 -6590 1970 -6590 {lab=row_n[9]}
N 1970 -6590 1980 -6580 {lab=row_n[9]}
N 1980 -6580 2110 -6580 {lab=row_n[9]}
N 1760 -6560 1770 -6570 {lab=rowon_n[9]}
N 1770 -6570 1970 -6570 {lab=rowon_n[9]}
N 1970 -6570 1980 -6560 {lab=rowon_n[9]}
N 1980 -6560 2110 -6560 {lab=rowon_n[9]}
N 1760 -6540 1770 -6550 {lab=#net17}
N 1770 -6550 1970 -6550 {lab=#net17}
N 1970 -6550 1980 -6540 {lab=#net17}
N 1980 -6540 2110 -6540 {lab=#net17}
N 1760 -6520 1770 -6530 {lab=#net18}
N 1770 -6530 1970 -6530 {lab=#net18}
N 1970 -6530 1980 -6520 {lab=#net18}
N 1980 -6520 2110 -6520 {lab=#net18}
N 2110 -6600 2120 -6610 {lab=rowoff_n[9]}
N 2120 -6610 2320 -6610 {lab=rowoff_n[9]}
N 2320 -6610 2330 -6600 {lab=rowoff_n[9]}
N 2330 -6600 2460 -6600 {lab=rowoff_n[9]}
N 2110 -6580 2120 -6590 {lab=row_n[9]}
N 2120 -6590 2320 -6590 {lab=row_n[9]}
N 2320 -6590 2330 -6580 {lab=row_n[9]}
N 2330 -6580 2460 -6580 {lab=row_n[9]}
N 2110 -6560 2120 -6570 {lab=rowon_n[9]}
N 2120 -6570 2320 -6570 {lab=rowon_n[9]}
N 2320 -6570 2330 -6560 {lab=rowon_n[9]}
N 2330 -6560 2460 -6560 {lab=rowon_n[9]}
N 2320 -6550 2330 -6540 {lab=#net17}
N 2330 -6540 2460 -6540 {lab=#net17}
N 2110 -6520 2120 -6530 {lab=#net18}
N 2120 -6530 2320 -6530 {lab=#net18}
N 2320 -6530 2330 -6520 {lab=#net18}
N 2330 -6520 2460 -6520 {lab=#net18}
N 2110 -6540 2120 -6550 {lab=#net17}
N 2120 -6550 2320 -6550 {lab=#net17}
N 2460 -6600 2470 -6610 {lab=rowoff_n[9]}
N 2470 -6610 2670 -6610 {lab=rowoff_n[9]}
N 2670 -6610 2680 -6600 {lab=rowoff_n[9]}
N 2680 -6600 2800 -6600 {lab=rowoff_n[9]}
N 2460 -6580 2470 -6590 {lab=row_n[9]}
N 2470 -6590 2670 -6590 {lab=row_n[9]}
N 2670 -6590 2680 -6580 {lab=row_n[9]}
N 2680 -6580 2800 -6580 {lab=row_n[9]}
N 2460 -6560 2470 -6570 {lab=rowon_n[9]}
N 2470 -6570 2670 -6570 {lab=rowon_n[9]}
N 2670 -6570 2680 -6560 {lab=rowon_n[9]}
N 2680 -6560 2800 -6560 {lab=rowon_n[9]}
N 2460 -6540 2470 -6550 {lab=#net17}
N 2470 -6550 2670 -6550 {lab=#net17}
N 2670 -6550 2680 -6540 {lab=#net17}
N 2680 -6540 2800 -6540 {lab=#net17}
N 2460 -6520 2470 -6530 {lab=#net18}
N 2470 -6530 2670 -6530 {lab=#net18}
N 2670 -6530 2680 -6520 {lab=#net18}
N 2680 -6520 2800 -6520 {lab=#net18}
N 2800 -6600 2810 -6610 {lab=rowoff_n[9]}
N 2810 -6610 3010 -6610 {lab=rowoff_n[9]}
N 3010 -6610 3020 -6600 {lab=rowoff_n[9]}
N 3020 -6600 3150 -6600 {lab=rowoff_n[9]}
N 2800 -6580 2810 -6590 {lab=row_n[9]}
N 2810 -6590 3010 -6590 {lab=row_n[9]}
N 3010 -6590 3020 -6580 {lab=row_n[9]}
N 3020 -6580 3150 -6580 {lab=row_n[9]}
N 2800 -6560 2810 -6570 {lab=rowon_n[9]}
N 2810 -6570 3010 -6570 {lab=rowon_n[9]}
N 3010 -6570 3020 -6560 {lab=rowon_n[9]}
N 3020 -6560 3150 -6560 {lab=rowon_n[9]}
N 2800 -6540 2810 -6550 {lab=#net17}
N 2810 -6550 3010 -6550 {lab=#net17}
N 2800 -6520 2810 -6530 {lab=#net18}
N 2810 -6530 3010 -6530 {lab=#net18}
N 3010 -6530 3020 -6520 {lab=#net18}
N 3020 -6520 3150 -6520 {lab=#net18}
N 3010 -6550 3020 -6540 {lab=#net17}
N 3020 -6540 3150 -6540 {lab=#net17}
N 3150 -6600 3160 -6610 {lab=rowoff_n[9]}
N 3160 -6610 3360 -6610 {lab=rowoff_n[9]}
N 3360 -6610 3370 -6600 {lab=rowoff_n[9]}
N 3370 -6600 3510 -6600 {lab=rowoff_n[9]}
N 3150 -6580 3160 -6590 {lab=row_n[9]}
N 3160 -6590 3360 -6590 {lab=row_n[9]}
N 3360 -6590 3370 -6580 {lab=row_n[9]}
N 3370 -6580 3510 -6580 {lab=row_n[9]}
N 3150 -6560 3160 -6570 {lab=rowon_n[9]}
N 3160 -6570 3360 -6570 {lab=rowon_n[9]}
N 3360 -6570 3370 -6560 {lab=rowon_n[9]}
N 3370 -6560 3510 -6560 {lab=rowon_n[9]}
N 3150 -6540 3160 -6550 {lab=#net17}
N 3160 -6550 3360 -6550 {lab=#net17}
N 3360 -6550 3370 -6540 {lab=#net17}
N 3370 -6540 3510 -6540 {lab=#net17}
N 3150 -6520 3160 -6530 {lab=#net18}
N 3160 -6530 3360 -6530 {lab=#net18}
N 3360 -6530 3370 -6520 {lab=#net18}
N 3370 -6520 3510 -6520 {lab=#net18}
N 3510 -6600 3520 -6610 {lab=rowoff_n[9]}
N 3520 -6610 3720 -6610 {lab=rowoff_n[9]}
N 3720 -6610 3730 -6600 {lab=rowoff_n[9]}
N 3730 -6600 3840 -6600 {lab=rowoff_n[9]}
N 3510 -6580 3520 -6590 {lab=row_n[9]}
N 3520 -6590 3720 -6590 {lab=row_n[9]}
N 3720 -6590 3730 -6580 {lab=row_n[9]}
N 3730 -6580 3840 -6580 {lab=row_n[9]}
N 3510 -6560 3520 -6570 {lab=rowon_n[9]}
N 3520 -6570 3720 -6570 {lab=rowon_n[9]}
N 3720 -6570 3730 -6560 {lab=rowon_n[9]}
N 3730 -6560 3840 -6560 {lab=rowon_n[9]}
N 3510 -6540 3520 -6550 {lab=#net17}
N 3520 -6550 3720 -6550 {lab=#net17}
N 3720 -6550 3730 -6540 {lab=#net17}
N 3730 -6540 3840 -6540 {lab=#net17}
N 3510 -6520 3520 -6530 {lab=#net18}
N 3520 -6530 3720 -6530 {lab=#net18}
N 3720 -6530 3730 -6520 {lab=#net18}
N 3730 -6520 3840 -6520 {lab=#net18}
N 3840 -6600 3850 -6610 {lab=rowoff_n[9]}
N 3850 -6610 4050 -6610 {lab=rowoff_n[9]}
N 4050 -6610 4060 -6600 {lab=rowoff_n[9]}
N 4060 -6600 4170 -6600 {lab=rowoff_n[9]}
N 3840 -6580 3850 -6590 {lab=row_n[9]}
N 3850 -6590 4050 -6590 {lab=row_n[9]}
N 4050 -6590 4060 -6580 {lab=row_n[9]}
N 4060 -6580 4170 -6580 {lab=row_n[9]}
N 3840 -6560 3850 -6570 {lab=rowon_n[9]}
N 3850 -6570 4050 -6570 {lab=rowon_n[9]}
N 4050 -6570 4060 -6560 {lab=rowon_n[9]}
N 4060 -6560 4170 -6560 {lab=rowon_n[9]}
N 3840 -6540 3850 -6550 {lab=#net17}
N 3850 -6550 4050 -6550 {lab=#net17}
N 4050 -6550 4060 -6540 {lab=#net17}
N 4060 -6540 4170 -6540 {lab=#net17}
N 3840 -6520 3850 -6530 {lab=#net18}
N 3850 -6530 4050 -6530 {lab=#net18}
N 4050 -6530 4070 -6520 {lab=#net18}
N 4070 -6520 4170 -6520 {lab=#net18}
N 4170 -6600 4180 -6610 {lab=rowoff_n[9]}
N 4180 -6610 4380 -6610 {lab=rowoff_n[9]}
N 4380 -6610 4390 -6600 {lab=rowoff_n[9]}
N 4390 -6600 4520 -6600 {lab=rowoff_n[9]}
N 4170 -6580 4180 -6590 {lab=row_n[9]}
N 4180 -6590 4380 -6590 {lab=row_n[9]}
N 4380 -6590 4390 -6580 {lab=row_n[9]}
N 4390 -6580 4520 -6580 {lab=row_n[9]}
N 4170 -6560 4180 -6570 {lab=rowon_n[9]}
N 4180 -6570 4380 -6570 {lab=rowon_n[9]}
N 4380 -6570 4390 -6560 {lab=rowon_n[9]}
N 4390 -6560 4520 -6560 {lab=rowon_n[9]}
N 4170 -6540 4180 -6550 {lab=#net17}
N 4180 -6550 4380 -6550 {lab=#net17}
N 4380 -6550 4390 -6540 {lab=#net17}
N 4390 -6540 4520 -6540 {lab=#net17}
N 4170 -6520 4180 -6530 {lab=#net18}
N 4180 -6530 4380 -6530 {lab=#net18}
N 4380 -6530 4390 -6520 {lab=#net18}
N 4390 -6520 4520 -6520 {lab=#net18}
N 4520 -6600 4530 -6610 {lab=rowoff_n[9]}
N 4530 -6610 4730 -6610 {lab=rowoff_n[9]}
N 4730 -6610 4740 -6600 {lab=rowoff_n[9]}
N 4740 -6600 4870 -6600 {lab=rowoff_n[9]}
N 4520 -6580 4530 -6590 {lab=row_n[9]}
N 4530 -6590 4730 -6590 {lab=row_n[9]}
N 4520 -6560 4530 -6570 {lab=rowon_n[9]}
N 4530 -6570 4730 -6570 {lab=rowon_n[9]}
N 4730 -6570 4740 -6560 {lab=rowon_n[9]}
N 4740 -6560 4870 -6560 {lab=rowon_n[9]}
N 4730 -6590 4740 -6580 {lab=row_n[9]}
N 4740 -6580 4870 -6580 {lab=row_n[9]}
N 4520 -6540 4530 -6550 {lab=#net17}
N 4530 -6550 4730 -6550 {lab=#net17}
N 4730 -6550 4740 -6540 {lab=#net17}
N 4740 -6540 4870 -6540 {lab=#net17}
N 4520 -6520 4530 -6530 {lab=#net18}
N 4530 -6530 4730 -6530 {lab=#net18}
N 4730 -6530 4740 -6520 {lab=#net18}
N 4740 -6520 4870 -6520 {lab=#net18}
N 4870 -6600 4880 -6610 {lab=rowoff_n[9]}
N 4880 -6610 5080 -6610 {lab=rowoff_n[9]}
N 5080 -6610 5090 -6600 {lab=rowoff_n[9]}
N 5090 -6600 5210 -6600 {lab=rowoff_n[9]}
N 4870 -6580 4880 -6590 {lab=row_n[9]}
N 4880 -6590 5080 -6590 {lab=row_n[9]}
N 5080 -6590 5090 -6580 {lab=row_n[9]}
N 5090 -6580 5210 -6580 {lab=row_n[9]}
N 4870 -6560 4880 -6570 {lab=rowon_n[9]}
N 4880 -6570 5080 -6570 {lab=rowon_n[9]}
N 5080 -6570 5090 -6560 {lab=rowon_n[9]}
N 5090 -6560 5210 -6560 {lab=rowon_n[9]}
N 4870 -6540 4880 -6550 {lab=#net17}
N 4880 -6550 5080 -6550 {lab=#net17}
N 5080 -6550 5090 -6540 {lab=#net17}
N 5090 -6540 5210 -6540 {lab=#net17}
N 4870 -6520 4880 -6530 {lab=#net18}
N 4880 -6530 5080 -6530 {lab=#net18}
N 5080 -6530 5090 -6520 {lab=#net18}
N 5090 -6520 5210 -6520 {lab=#net18}
N 5210 -6600 5220 -6610 {lab=rowoff_n[9]}
N 5220 -6610 5420 -6610 {lab=rowoff_n[9]}
N 5420 -6610 5430 -6600 {lab=rowoff_n[9]}
N 5430 -6600 5550 -6600 {lab=rowoff_n[9]}
N 5210 -6580 5220 -6590 {lab=row_n[9]}
N 5220 -6590 5420 -6590 {lab=row_n[9]}
N 5420 -6590 5430 -6580 {lab=row_n[9]}
N 5430 -6580 5550 -6580 {lab=row_n[9]}
N 5210 -6560 5220 -6570 {lab=rowon_n[9]}
N 5220 -6570 5420 -6570 {lab=rowon_n[9]}
N 5420 -6570 5430 -6560 {lab=rowon_n[9]}
N 5430 -6560 5550 -6560 {lab=rowon_n[9]}
N 5210 -6540 5220 -6550 {lab=#net17}
N 5220 -6550 5420 -6550 {lab=#net17}
N 5420 -6550 5430 -6540 {lab=#net17}
N 5430 -6540 5550 -6540 {lab=#net17}
N 5210 -6520 5220 -6530 {lab=#net18}
N 5220 -6530 5420 -6530 {lab=#net18}
N 5420 -6530 5440 -6520 {lab=#net18}
N 5440 -6520 5550 -6520 {lab=#net18}
N 5550 -6600 5560 -6610 {lab=rowoff_n[9]}
N 5560 -6610 5760 -6610 {lab=rowoff_n[9]}
N 5550 -6580 5560 -6590 {lab=row_n[9]}
N 5560 -6590 5760 -6590 {lab=row_n[9]}
N 5760 -6590 5770 -6580 {lab=row_n[9]}
N 5760 -6610 5770 -6600 {lab=rowoff_n[9]}
N 5550 -6560 5560 -6570 {lab=rowon_n[9]}
N 5560 -6570 5760 -6570 {lab=rowon_n[9]}
N 5550 -6540 5560 -6550 {lab=#net17}
N 5560 -6550 5760 -6550 {lab=#net17}
N 5760 -6550 5770 -6540 {lab=#net17}
N 5550 -6520 5560 -6530 {lab=#net18}
N 5560 -6530 5760 -6530 {lab=#net18}
N 5760 -6530 5770 -6520 {lab=#net18}
N 5760 -6570 5770 -6560 {lab=rowon_n[9]}
N 800 -6770 800 -6760 {
lab=VSS}
N 1120 -6770 1120 -6760 {
lab=VSS}
N 1450 -6770 1450 -6760 {
lab=VSS}
N 1800 -6770 1800 -6760 {
lab=VSS}
N 2150 -6770 2150 -6760 {
lab=VSS}
N 2500 -6770 2500 -6760 {
lab=VSS}
N 2840 -6770 2840 -6760 {
lab=VSS}
N 3190 -6770 3190 -6760 {
lab=VSS}
N 3550 -6770 3550 -6760 {
lab=VSS}
N 3880 -6770 3880 -6760 {
lab=VSS}
N 4210 -6770 4210 -6760 {
lab=VSS}
N 4560 -6770 4560 -6760 {
lab=VSS}
N 4910 -6770 4910 -6760 {
lab=VSS}
N 5250 -6770 5250 -6760 {
lab=VSS}
N 5590 -6770 5590 -6760 {
lab=VSS}
N 5610 -7010 5610 -6990 {
lab=vcm}
N 5590 -7000 5590 -6990 {
lab=VDD}
N 5650 -7010 5650 -6990 {
lab=ctop}
N 4930 -7010 4930 -6990 {
lab=vcm}
N 4910 -7000 4910 -6990 {
lab=VDD}
N 4970 -7010 4970 -6990 {
lab=ctop}
N 5270 -7010 5270 -6990 {
lab=vcm}
N 5250 -7000 5250 -6990 {
lab=VDD}
N 5310 -7010 5310 -6990 {
lab=ctop}
N 4580 -7010 4580 -6990 {
lab=vcm}
N 4560 -7000 4560 -6990 {
lab=VDD}
N 4620 -7010 4620 -6990 {
lab=ctop}
N 4230 -7010 4230 -6990 {
lab=vcm}
N 4210 -7000 4210 -6990 {
lab=VDD}
N 4270 -7010 4270 -6990 {
lab=ctop}
N 3900 -7010 3900 -6990 {
lab=vcm}
N 3880 -7000 3880 -6990 {
lab=VDD}
N 3940 -7010 3940 -6990 {
lab=ctop}
N 3570 -7010 3570 -6990 {
lab=vcm}
N 3550 -7000 3550 -6990 {
lab=VDD}
N 3610 -7010 3610 -6990 {
lab=ctop}
N 3210 -7010 3210 -6990 {
lab=vcm}
N 3190 -7000 3190 -6990 {
lab=VDD}
N 3250 -7010 3250 -6990 {
lab=ctop}
N 2860 -7010 2860 -6990 {
lab=vcm}
N 2840 -7000 2840 -6990 {
lab=VDD}
N 2900 -7010 2900 -6990 {
lab=ctop}
N 2520 -7010 2520 -6990 {
lab=vcm}
N 2500 -7000 2500 -6990 {
lab=VDD}
N 2560 -7010 2560 -6990 {
lab=ctop}
N 2170 -7010 2170 -6990 {
lab=vcm}
N 2150 -7000 2150 -6990 {
lab=VDD}
N 2210 -7010 2210 -6990 {
lab=ctop}
N 1820 -7010 1820 -6990 {
lab=vcm}
N 1800 -7000 1800 -6990 {
lab=VDD}
N 1860 -7010 1860 -6990 {
lab=ctop}
N 1470 -7010 1470 -6990 {
lab=vcm}
N 1450 -7000 1450 -6990 {
lab=VDD}
N 1510 -7010 1510 -6990 {
lab=ctop}
N 1140 -7010 1140 -6990 {
lab=vcm}
N 1120 -7000 1120 -6990 {
lab=VDD}
N 1180 -7010 1180 -6990 {
lab=ctop}
N 820 -7010 820 -6990 {
lab=vcm}
N 800 -7000 800 -6990 {
lab=VDD}
N 860 -7010 860 -6990 {
lab=ctop}
N 740 -6850 760 -6850 {
lab=sample_n}
N 740 -6870 760 -6870 {
lab=sample}
N 740 -6890 760 -6890 {
lab=VDD}
N 740 -6910 760 -6910 {
lab=VDD}
N 740 -6930 760 -6930 {
lab=VSS}
N 980 -6870 1080 -6870 {lab=#net19}
N 980 -6850 1080 -6850 {lab=#net20}
N 760 -6930 770 -6940 {lab=VSS}
N 770 -6940 990 -6940 {lab=VSS}
N 990 -6940 1000 -6930 {lab=VSS}
N 1000 -6930 1080 -6930 {lab=VSS}
N 760 -6910 770 -6920 {lab=VDD}
N 770 -6920 990 -6920 {lab=VDD}
N 990 -6920 1000 -6910 {lab=VDD}
N 1000 -6910 1080 -6910 {lab=VDD}
N 760 -6890 770 -6900 {lab=VDD}
N 770 -6900 990 -6900 {lab=VDD}
N 990 -6900 1000 -6890 {lab=VDD}
N 1000 -6890 1080 -6890 {lab=VDD}
N 1080 -6930 1090 -6940 {lab=VSS}
N 1080 -6910 1090 -6920 {lab=VDD}
N 1090 -6920 1290 -6920 {lab=VDD}
N 1290 -6920 1300 -6910 {lab=VDD}
N 1300 -6910 1410 -6910 {lab=VDD}
N 1090 -6940 1290 -6940 {lab=VSS}
N 1290 -6940 1300 -6930 {lab=VSS}
N 1300 -6930 1410 -6930 {lab=VSS}
N 1080 -6890 1090 -6900 {lab=VDD}
N 1090 -6900 1290 -6900 {lab=VDD}
N 1290 -6900 1300 -6890 {lab=VDD}
N 1300 -6890 1410 -6890 {lab=VDD}
N 1080 -6870 1090 -6880 {lab=#net19}
N 1090 -6880 1290 -6880 {lab=#net19}
N 1290 -6880 1300 -6870 {lab=#net19}
N 1300 -6870 1410 -6870 {lab=#net19}
N 1080 -6850 1090 -6860 {lab=#net20}
N 1090 -6860 1290 -6860 {lab=#net20}
N 1290 -6860 1300 -6850 {lab=#net20}
N 1300 -6850 1410 -6850 {lab=#net20}
N 1410 -6910 1420 -6920 {lab=VDD}
N 1420 -6920 1620 -6920 {lab=VDD}
N 1620 -6920 1630 -6910 {lab=VDD}
N 1630 -6910 1760 -6910 {lab=VDD}
N 1410 -6890 1420 -6900 {lab=VDD}
N 1420 -6900 1620 -6900 {lab=VDD}
N 1620 -6900 1630 -6890 {lab=VDD}
N 1630 -6890 1760 -6890 {lab=VDD}
N 1410 -6870 1420 -6880 {lab=#net19}
N 1420 -6880 1620 -6880 {lab=#net19}
N 1620 -6880 1630 -6870 {lab=#net19}
N 1630 -6870 1760 -6870 {lab=#net19}
N 1410 -6850 1430 -6860 {lab=#net20}
N 1430 -6860 1620 -6860 {lab=#net20}
N 1620 -6860 1630 -6850 {lab=#net20}
N 1630 -6850 1760 -6850 {lab=#net20}
N 1410 -6930 1420 -6940 {lab=VSS}
N 1420 -6940 1620 -6940 {lab=VSS}
N 1620 -6940 1630 -6930 {lab=VSS}
N 1630 -6930 1760 -6930 {lab=VSS}
N 1760 -6930 1770 -6940 {lab=VSS}
N 1770 -6940 1970 -6940 {lab=VSS}
N 1970 -6940 1980 -6930 {lab=VSS}
N 1980 -6930 2110 -6930 {lab=VSS}
N 1760 -6910 1770 -6920 {lab=VDD}
N 1770 -6920 1970 -6920 {lab=VDD}
N 1970 -6920 1980 -6910 {lab=VDD}
N 1980 -6910 2110 -6910 {lab=VDD}
N 1760 -6890 1770 -6900 {lab=VDD}
N 1770 -6900 1970 -6900 {lab=VDD}
N 1970 -6900 1980 -6890 {lab=VDD}
N 1980 -6890 2110 -6890 {lab=VDD}
N 1760 -6870 1770 -6880 {lab=#net19}
N 1770 -6880 1970 -6880 {lab=#net19}
N 1970 -6880 1980 -6870 {lab=#net19}
N 1980 -6870 2110 -6870 {lab=#net19}
N 1760 -6850 1770 -6860 {lab=#net20}
N 1770 -6860 1970 -6860 {lab=#net20}
N 1970 -6860 1980 -6850 {lab=#net20}
N 1980 -6850 2110 -6850 {lab=#net20}
N 2110 -6930 2120 -6940 {lab=VSS}
N 2120 -6940 2320 -6940 {lab=VSS}
N 2320 -6940 2330 -6930 {lab=VSS}
N 2330 -6930 2460 -6930 {lab=VSS}
N 2110 -6910 2120 -6920 {lab=VDD}
N 2120 -6920 2320 -6920 {lab=VDD}
N 2320 -6920 2330 -6910 {lab=VDD}
N 2330 -6910 2460 -6910 {lab=VDD}
N 2110 -6890 2120 -6900 {lab=VDD}
N 2120 -6900 2320 -6900 {lab=VDD}
N 2320 -6900 2330 -6890 {lab=VDD}
N 2330 -6890 2460 -6890 {lab=VDD}
N 2320 -6880 2330 -6870 {lab=#net19}
N 2330 -6870 2460 -6870 {lab=#net19}
N 2110 -6850 2120 -6860 {lab=#net20}
N 2120 -6860 2320 -6860 {lab=#net20}
N 2320 -6860 2330 -6850 {lab=#net20}
N 2330 -6850 2460 -6850 {lab=#net20}
N 2110 -6870 2120 -6880 {lab=#net19}
N 2120 -6880 2320 -6880 {lab=#net19}
N 2460 -6930 2470 -6940 {lab=VSS}
N 2470 -6940 2670 -6940 {lab=VSS}
N 2670 -6940 2680 -6930 {lab=VSS}
N 2680 -6930 2800 -6930 {lab=VSS}
N 2460 -6910 2470 -6920 {lab=VDD}
N 2470 -6920 2670 -6920 {lab=VDD}
N 2670 -6920 2680 -6910 {lab=VDD}
N 2680 -6910 2800 -6910 {lab=VDD}
N 2460 -6890 2470 -6900 {lab=VDD}
N 2470 -6900 2670 -6900 {lab=VDD}
N 2670 -6900 2680 -6890 {lab=VDD}
N 2680 -6890 2800 -6890 {lab=VDD}
N 2460 -6870 2470 -6880 {lab=#net19}
N 2470 -6880 2670 -6880 {lab=#net19}
N 2670 -6880 2680 -6870 {lab=#net19}
N 2680 -6870 2800 -6870 {lab=#net19}
N 2460 -6850 2470 -6860 {lab=#net20}
N 2470 -6860 2670 -6860 {lab=#net20}
N 2670 -6860 2680 -6850 {lab=#net20}
N 2680 -6850 2800 -6850 {lab=#net20}
N 2800 -6930 2810 -6940 {lab=VSS}
N 2810 -6940 3010 -6940 {lab=VSS}
N 3010 -6940 3020 -6930 {lab=VSS}
N 3020 -6930 3150 -6930 {lab=VSS}
N 2800 -6910 2810 -6920 {lab=VDD}
N 2810 -6920 3010 -6920 {lab=VDD}
N 3010 -6920 3020 -6910 {lab=VDD}
N 3020 -6910 3150 -6910 {lab=VDD}
N 2800 -6890 2810 -6900 {lab=VDD}
N 2810 -6900 3010 -6900 {lab=VDD}
N 3010 -6900 3020 -6890 {lab=VDD}
N 3020 -6890 3150 -6890 {lab=VDD}
N 2800 -6870 2810 -6880 {lab=#net19}
N 2810 -6880 3010 -6880 {lab=#net19}
N 2800 -6850 2810 -6860 {lab=#net20}
N 2810 -6860 3010 -6860 {lab=#net20}
N 3010 -6860 3020 -6850 {lab=#net20}
N 3020 -6850 3150 -6850 {lab=#net20}
N 3010 -6880 3020 -6870 {lab=#net19}
N 3020 -6870 3150 -6870 {lab=#net19}
N 3150 -6930 3160 -6940 {lab=VSS}
N 3160 -6940 3360 -6940 {lab=VSS}
N 3360 -6940 3370 -6930 {lab=VSS}
N 3370 -6930 3510 -6930 {lab=VSS}
N 3150 -6910 3160 -6920 {lab=VDD}
N 3160 -6920 3360 -6920 {lab=VDD}
N 3360 -6920 3370 -6910 {lab=VDD}
N 3370 -6910 3510 -6910 {lab=VDD}
N 3150 -6890 3160 -6900 {lab=VDD}
N 3160 -6900 3360 -6900 {lab=VDD}
N 3360 -6900 3370 -6890 {lab=VDD}
N 3370 -6890 3510 -6890 {lab=VDD}
N 3150 -6870 3160 -6880 {lab=#net19}
N 3160 -6880 3360 -6880 {lab=#net19}
N 3360 -6880 3370 -6870 {lab=#net19}
N 3370 -6870 3510 -6870 {lab=#net19}
N 3150 -6850 3160 -6860 {lab=#net20}
N 3160 -6860 3360 -6860 {lab=#net20}
N 3360 -6860 3370 -6850 {lab=#net20}
N 3370 -6850 3510 -6850 {lab=#net20}
N 3510 -6930 3520 -6940 {lab=VSS}
N 3520 -6940 3720 -6940 {lab=VSS}
N 3720 -6940 3730 -6930 {lab=VSS}
N 3730 -6930 3840 -6930 {lab=VSS}
N 3510 -6910 3520 -6920 {lab=VDD}
N 3520 -6920 3720 -6920 {lab=VDD}
N 3720 -6920 3730 -6910 {lab=VDD}
N 3730 -6910 3840 -6910 {lab=VDD}
N 3510 -6890 3520 -6900 {lab=VDD}
N 3520 -6900 3720 -6900 {lab=VDD}
N 3720 -6900 3730 -6890 {lab=VDD}
N 3730 -6890 3840 -6890 {lab=VDD}
N 3510 -6870 3520 -6880 {lab=#net19}
N 3520 -6880 3720 -6880 {lab=#net19}
N 3720 -6880 3730 -6870 {lab=#net19}
N 3730 -6870 3840 -6870 {lab=#net19}
N 3510 -6850 3520 -6860 {lab=#net20}
N 3520 -6860 3720 -6860 {lab=#net20}
N 3720 -6860 3730 -6850 {lab=#net20}
N 3730 -6850 3840 -6850 {lab=#net20}
N 3840 -6930 3850 -6940 {lab=VSS}
N 3850 -6940 4050 -6940 {lab=VSS}
N 4050 -6940 4060 -6930 {lab=VSS}
N 4060 -6930 4170 -6930 {lab=VSS}
N 3840 -6910 3850 -6920 {lab=VDD}
N 3850 -6920 4050 -6920 {lab=VDD}
N 4050 -6920 4060 -6910 {lab=VDD}
N 4060 -6910 4170 -6910 {lab=VDD}
N 3840 -6890 3850 -6900 {lab=VDD}
N 3850 -6900 4050 -6900 {lab=VDD}
N 4050 -6900 4060 -6890 {lab=VDD}
N 4060 -6890 4170 -6890 {lab=VDD}
N 3840 -6870 3850 -6880 {lab=#net19}
N 3850 -6880 4050 -6880 {lab=#net19}
N 4050 -6880 4060 -6870 {lab=#net19}
N 4060 -6870 4170 -6870 {lab=#net19}
N 3840 -6850 3850 -6860 {lab=#net20}
N 3850 -6860 4050 -6860 {lab=#net20}
N 4050 -6860 4070 -6850 {lab=#net20}
N 4070 -6850 4170 -6850 {lab=#net20}
N 4170 -6930 4180 -6940 {lab=VSS}
N 4180 -6940 4380 -6940 {lab=VSS}
N 4380 -6940 4390 -6930 {lab=VSS}
N 4390 -6930 4520 -6930 {lab=VSS}
N 4170 -6910 4180 -6920 {lab=VDD}
N 4180 -6920 4380 -6920 {lab=VDD}
N 4380 -6920 4390 -6910 {lab=VDD}
N 4390 -6910 4520 -6910 {lab=VDD}
N 4170 -6890 4180 -6900 {lab=VDD}
N 4180 -6900 4380 -6900 {lab=VDD}
N 4380 -6900 4390 -6890 {lab=VDD}
N 4390 -6890 4520 -6890 {lab=VDD}
N 4170 -6870 4180 -6880 {lab=#net19}
N 4180 -6880 4380 -6880 {lab=#net19}
N 4380 -6880 4390 -6870 {lab=#net19}
N 4390 -6870 4520 -6870 {lab=#net19}
N 4170 -6850 4180 -6860 {lab=#net20}
N 4180 -6860 4380 -6860 {lab=#net20}
N 4380 -6860 4390 -6850 {lab=#net20}
N 4390 -6850 4520 -6850 {lab=#net20}
N 4520 -6930 4530 -6940 {lab=VSS}
N 4530 -6940 4730 -6940 {lab=VSS}
N 4730 -6940 4740 -6930 {lab=VSS}
N 4740 -6930 4870 -6930 {lab=VSS}
N 4520 -6910 4530 -6920 {lab=VDD}
N 4530 -6920 4730 -6920 {lab=VDD}
N 4520 -6890 4530 -6900 {lab=VDD}
N 4530 -6900 4730 -6900 {lab=VDD}
N 4730 -6900 4740 -6890 {lab=VDD}
N 4740 -6890 4870 -6890 {lab=VDD}
N 4730 -6920 4740 -6910 {lab=VDD}
N 4740 -6910 4870 -6910 {lab=VDD}
N 4520 -6870 4530 -6880 {lab=#net19}
N 4530 -6880 4730 -6880 {lab=#net19}
N 4730 -6880 4740 -6870 {lab=#net19}
N 4740 -6870 4870 -6870 {lab=#net19}
N 4520 -6850 4530 -6860 {lab=#net20}
N 4530 -6860 4730 -6860 {lab=#net20}
N 4730 -6860 4740 -6850 {lab=#net20}
N 4740 -6850 4870 -6850 {lab=#net20}
N 4870 -6930 4880 -6940 {lab=VSS}
N 4880 -6940 5080 -6940 {lab=VSS}
N 5080 -6940 5090 -6930 {lab=VSS}
N 5090 -6930 5210 -6930 {lab=VSS}
N 4870 -6910 4880 -6920 {lab=VDD}
N 4880 -6920 5080 -6920 {lab=VDD}
N 5080 -6920 5090 -6910 {lab=VDD}
N 5090 -6910 5210 -6910 {lab=VDD}
N 4870 -6890 4880 -6900 {lab=VDD}
N 4880 -6900 5080 -6900 {lab=VDD}
N 5080 -6900 5090 -6890 {lab=VDD}
N 5090 -6890 5210 -6890 {lab=VDD}
N 4870 -6870 4880 -6880 {lab=#net19}
N 4880 -6880 5080 -6880 {lab=#net19}
N 5080 -6880 5090 -6870 {lab=#net19}
N 5090 -6870 5210 -6870 {lab=#net19}
N 4870 -6850 4880 -6860 {lab=#net20}
N 4880 -6860 5080 -6860 {lab=#net20}
N 5080 -6860 5090 -6850 {lab=#net20}
N 5090 -6850 5210 -6850 {lab=#net20}
N 5210 -6930 5220 -6940 {lab=VSS}
N 5220 -6940 5420 -6940 {lab=VSS}
N 5420 -6940 5430 -6930 {lab=VSS}
N 5430 -6930 5550 -6930 {lab=VSS}
N 5210 -6910 5220 -6920 {lab=VDD}
N 5220 -6920 5420 -6920 {lab=VDD}
N 5420 -6920 5430 -6910 {lab=VDD}
N 5430 -6910 5550 -6910 {lab=VDD}
N 5210 -6890 5220 -6900 {lab=VDD}
N 5220 -6900 5420 -6900 {lab=VDD}
N 5420 -6900 5430 -6890 {lab=VDD}
N 5430 -6890 5550 -6890 {lab=VDD}
N 5210 -6870 5220 -6880 {lab=#net19}
N 5220 -6880 5420 -6880 {lab=#net19}
N 5420 -6880 5430 -6870 {lab=#net19}
N 5430 -6870 5550 -6870 {lab=#net19}
N 5210 -6850 5220 -6860 {lab=#net20}
N 5220 -6860 5420 -6860 {lab=#net20}
N 5420 -6860 5440 -6850 {lab=#net20}
N 5440 -6850 5550 -6850 {lab=#net20}
N 5550 -6930 5560 -6940 {lab=VSS}
N 5560 -6940 5760 -6940 {lab=VSS}
N 5550 -6910 5560 -6920 {lab=VDD}
N 5560 -6920 5760 -6920 {lab=VDD}
N 5760 -6920 5770 -6910 {lab=VDD}
N 5760 -6940 5770 -6930 {lab=VSS}
N 5550 -6890 5560 -6900 {lab=VDD}
N 5560 -6900 5760 -6900 {lab=VDD}
N 5550 -6870 5560 -6880 {lab=#net19}
N 5560 -6880 5760 -6880 {lab=#net19}
N 5760 -6880 5770 -6870 {lab=#net19}
N 5550 -6850 5560 -6860 {lab=#net20}
N 5560 -6860 5760 -6860 {lab=#net20}
N 5760 -6860 5770 -6850 {lab=#net20}
N 5760 -6900 5770 -6890 {lab=VDD}
N 880 -6440 890 -6450 {lab=VDD}
N 890 -6700 890 -6450 {lab=VDD}
N 880 -6710 890 -6700 {lab=VDD}
N 880 -6770 880 -6710 {lab=VDD}
N 900 -6770 900 -6710 {lab=VSS}
N 900 -6710 910 -6700 {lab=VSS}
N 910 -6700 910 -6450 {lab=VSS}
N 900 -6440 910 -6450 {lab=VSS}
N 1210 -6700 1210 -6450 {lab=col_n[0]}
N 1200 -6710 1210 -6700 {lab=col_n[0]}
N 1200 -6770 1200 -6710 {lab=col_n[0]}
N 1220 -6770 1220 -6710 {lab=col[0]}
N 1220 -6710 1230 -6700 {lab=col[0]}
N 1230 -6700 1230 -6450 {lab=col[0]}
N 1540 -6700 1540 -6450 {lab=col_n[1]}
N 1530 -6710 1540 -6700 {lab=col_n[1]}
N 1530 -6770 1530 -6710 {lab=col_n[1]}
N 1550 -6770 1550 -6710 {lab=col[1]}
N 1550 -6710 1560 -6700 {lab=col[1]}
N 1560 -6700 1560 -6450 {lab=col[1]}
N 1890 -6700 1890 -6450 {lab=col_n[2]}
N 1880 -6710 1890 -6700 {lab=col_n[2]}
N 1880 -6770 1880 -6710 {lab=col_n[2]}
N 1900 -6770 1900 -6710 {lab=col[2]}
N 1900 -6710 1910 -6700 {lab=col[2]}
N 1910 -6700 1910 -6450 {lab=col[2]}
N 2240 -6700 2240 -6450 {lab=col_n[3]}
N 2230 -6710 2240 -6700 {lab=col_n[3]}
N 2230 -6770 2230 -6710 {lab=col_n[3]}
N 2250 -6770 2250 -6710 {lab=col[3]}
N 2250 -6710 2260 -6700 {lab=col[3]}
N 2260 -6700 2260 -6450 {lab=col[3]}
N 2590 -6700 2590 -6450 {lab=col_n[4]}
N 2580 -6710 2590 -6700 {lab=col_n[4]}
N 2580 -6770 2580 -6710 {lab=col_n[4]}
N 2600 -6770 2600 -6710 {lab=col[4]}
N 2600 -6710 2610 -6700 {lab=col[4]}
N 2610 -6700 2610 -6450 {lab=col[4]}
N 2930 -6700 2930 -6450 {lab=col_n[5]}
N 2920 -6710 2930 -6700 {lab=col_n[5]}
N 2920 -6770 2920 -6710 {lab=col_n[5]}
N 2940 -6770 2940 -6710 {lab=col[5]}
N 2940 -6710 2950 -6700 {lab=col[5]}
N 2950 -6700 2950 -6450 {lab=col[5]}
N 3280 -6700 3280 -6450 {lab=col_n[6]}
N 3270 -6710 3280 -6700 {lab=col_n[6]}
N 3270 -6770 3270 -6710 {lab=col_n[6]}
N 3290 -6770 3290 -6710 {lab=col[6]}
N 3290 -6710 3300 -6700 {lab=col[6]}
N 3300 -6700 3300 -6450 {lab=col[6]}
N 3640 -6700 3640 -6450 {lab=col_n[7]}
N 3630 -6710 3640 -6700 {lab=col_n[7]}
N 3630 -6770 3630 -6710 {lab=col_n[7]}
N 3650 -6770 3650 -6710 {lab=col[7]}
N 3650 -6710 3660 -6700 {lab=col[7]}
N 3660 -6700 3660 -6450 {lab=col[7]}
N 3970 -6700 3970 -6450 {lab=col_n[8]}
N 3960 -6710 3970 -6700 {lab=col_n[8]}
N 3960 -6770 3960 -6710 {lab=col_n[8]}
N 3980 -6770 3980 -6710 {lab=col[8]}
N 3980 -6710 3990 -6700 {lab=col[8]}
N 3990 -6700 3990 -6450 {lab=col[8]}
N 4300 -6700 4300 -6450 {lab=col_n[9]}
N 4290 -6710 4300 -6700 {lab=col_n[9]}
N 4290 -6770 4290 -6710 {lab=col_n[9]}
N 4310 -6770 4310 -6710 {lab=col[9]}
N 4310 -6710 4320 -6700 {lab=col[9]}
N 4320 -6700 4320 -6450 {lab=col[9]}
N 4650 -6700 4650 -6450 {lab=col_n[10]}
N 4640 -6710 4650 -6700 {lab=col_n[10]}
N 4640 -6770 4640 -6710 {lab=col_n[10]}
N 4660 -6770 4660 -6710 {lab=col[10]}
N 4660 -6710 4670 -6700 {lab=col[10]}
N 4670 -6700 4670 -6450 {lab=col[10]}
N 5000 -6700 5000 -6450 {lab=col_n[11]}
N 4990 -6710 5000 -6700 {lab=col_n[11]}
N 4990 -6770 4990 -6710 {lab=col_n[11]}
N 5010 -6770 5010 -6710 {lab=col[11]}
N 5010 -6710 5020 -6700 {lab=col[11]}
N 5020 -6700 5020 -6450 {lab=col[11]}
N 5340 -6700 5340 -6450 {lab=col_n[12]}
N 5330 -6710 5340 -6700 {lab=col_n[12]}
N 5330 -6770 5330 -6710 {lab=col_n[12]}
N 5350 -6770 5350 -6710 {lab=col[12]}
N 5350 -6710 5360 -6700 {lab=col[12]}
N 5360 -6700 5360 -6450 {lab=col[12]}
N 5680 -6700 5680 -6450 {lab=VDD}
N 5670 -6710 5680 -6700 {lab=VDD}
N 5670 -6770 5670 -6710 {lab=VDD}
N 5690 -6770 5690 -6710 {lab=VSS}
N 5690 -6710 5700 -6700 {lab=VSS}
N 5700 -6700 5700 -6450 {lab=VSS}
N 5690 -6440 5700 -6450 {lab=VSS}
N 5670 -6440 5680 -6450 {lab=VDD}
N 5330 -6440 5340 -6450 {lab=col_n[12]}
N 5350 -6440 5360 -6450 {lab=col[12]}
N 4990 -6440 5000 -6450 {lab=col_n[11]}
N 5010 -6440 5020 -6450 {lab=col[11]}
N 4640 -6440 4650 -6450 {lab=col_n[10]}
N 4660 -6440 4670 -6450 {lab=col[10]}
N 4310 -6440 4320 -6450 {lab=col[9]}
N 4290 -6440 4300 -6450 {lab=col_n[9]}
N 3980 -6440 3990 -6450 {lab=col[8]}
N 3960 -6440 3970 -6450 {lab=col_n[8]}
N 3630 -6440 3640 -6450 {lab=col_n[7]}
N 3650 -6440 3660 -6450 {lab=col[7]}
N 3270 -6440 3280 -6450 {lab=col_n[6]}
N 3290 -6440 3300 -6450 {lab=col[6]}
N 2940 -6440 2950 -6450 {lab=col[5]}
N 2920 -6440 2930 -6450 {lab=col_n[5]}
N 2600 -6440 2610 -6450 {lab=col[4]}
N 2580 -6440 2590 -6450 {lab=col_n[4]}
N 2250 -6440 2260 -6450 {lab=col[3]}
N 2230 -6440 2240 -6450 {lab=col_n[3]}
N 1900 -6440 1910 -6450 {lab=col[2]}
N 1880 -6440 1890 -6450 {lab=col_n[2]}
N 1550 -6440 1560 -6450 {lab=col[1]}
N 1530 -6440 1540 -6450 {lab=col_n[1]}
N 1200 -6440 1210 -6450 {lab=col_n[0]}
N 1220 -6440 1230 -6450 {lab=col[0]}
N 880 -6130 890 -6140 {lab=VDD}
N 880 -6440 880 -6400 {lab=VDD}
N 900 -6130 910 -6140 {lab=VSS}
N 910 -6380 910 -6140 {lab=VSS}
N 900 -6390 910 -6380 {lab=VSS}
N 900 -6440 900 -6390 {lab=VSS}
N 890 -6380 890 -6140 {lab=VDD}
N 880 -6390 890 -6380 {lab=VDD}
N 880 -6400 880 -6390 {lab=VDD}
N 1200 -6440 1200 -6400 {lab=col_n[0]}
N 1230 -6380 1230 -6140 {lab=col[0]}
N 1220 -6390 1230 -6380 {lab=col[0]}
N 1220 -6440 1220 -6390 {lab=col[0]}
N 1210 -6380 1210 -6140 {lab=col_n[0]}
N 1200 -6390 1210 -6380 {lab=col_n[0]}
N 1200 -6400 1200 -6390 {lab=col_n[0]}
N 1530 -6440 1530 -6400 {lab=col_n[1]}
N 1560 -6380 1560 -6140 {lab=col[1]}
N 1550 -6390 1560 -6380 {lab=col[1]}
N 1550 -6440 1550 -6390 {lab=col[1]}
N 1540 -6380 1540 -6140 {lab=col_n[1]}
N 1530 -6390 1540 -6380 {lab=col_n[1]}
N 1530 -6400 1530 -6390 {lab=col_n[1]}
N 1880 -6440 1880 -6400 {lab=col_n[2]}
N 1910 -6380 1910 -6140 {lab=col[2]}
N 1900 -6390 1910 -6380 {lab=col[2]}
N 1900 -6440 1900 -6390 {lab=col[2]}
N 1890 -6380 1890 -6140 {lab=col_n[2]}
N 1880 -6390 1890 -6380 {lab=col_n[2]}
N 1880 -6400 1880 -6390 {lab=col_n[2]}
N 2230 -6440 2230 -6400 {lab=col_n[3]}
N 2260 -6380 2260 -6140 {lab=col[3]}
N 2250 -6390 2260 -6380 {lab=col[3]}
N 2250 -6440 2250 -6390 {lab=col[3]}
N 2240 -6380 2240 -6140 {lab=col_n[3]}
N 2230 -6390 2240 -6380 {lab=col_n[3]}
N 2230 -6400 2230 -6390 {lab=col_n[3]}
N 2580 -6440 2580 -6400 {lab=col_n[4]}
N 2610 -6380 2610 -6140 {lab=col[4]}
N 2600 -6390 2610 -6380 {lab=col[4]}
N 2600 -6440 2600 -6390 {lab=col[4]}
N 2590 -6380 2590 -6140 {lab=col_n[4]}
N 2580 -6390 2590 -6380 {lab=col_n[4]}
N 2580 -6400 2580 -6390 {lab=col_n[4]}
N 2920 -6440 2920 -6400 {lab=col_n[5]}
N 2950 -6380 2950 -6140 {lab=col[5]}
N 2940 -6390 2950 -6380 {lab=col[5]}
N 2940 -6440 2940 -6390 {lab=col[5]}
N 2930 -6380 2930 -6140 {lab=col_n[5]}
N 2920 -6390 2930 -6380 {lab=col_n[5]}
N 2920 -6400 2920 -6390 {lab=col_n[5]}
N 3270 -6440 3270 -6400 {lab=col_n[6]}
N 3300 -6380 3300 -6140 {lab=col[6]}
N 3290 -6390 3300 -6380 {lab=col[6]}
N 3290 -6440 3290 -6390 {lab=col[6]}
N 3280 -6380 3280 -6140 {lab=col_n[6]}
N 3270 -6390 3280 -6380 {lab=col_n[6]}
N 3270 -6400 3270 -6390 {lab=col_n[6]}
N 3630 -6440 3630 -6400 {lab=col_n[7]}
N 3660 -6380 3660 -6140 {lab=col[7]}
N 3650 -6390 3660 -6380 {lab=col[7]}
N 3650 -6440 3650 -6390 {lab=col[7]}
N 3640 -6380 3640 -6140 {lab=col_n[7]}
N 3630 -6390 3640 -6380 {lab=col_n[7]}
N 3630 -6400 3630 -6390 {lab=col_n[7]}
N 3960 -6440 3960 -6400 {lab=col_n[8]}
N 3990 -6380 3990 -6140 {lab=col[8]}
N 3980 -6390 3990 -6380 {lab=col[8]}
N 3980 -6440 3980 -6390 {lab=col[8]}
N 3970 -6380 3970 -6140 {lab=col_n[8]}
N 3960 -6390 3970 -6380 {lab=col_n[8]}
N 3960 -6400 3960 -6390 {lab=col_n[8]}
N 4290 -6440 4290 -6400 {lab=col_n[9]}
N 4320 -6380 4320 -6140 {lab=col[9]}
N 4310 -6390 4320 -6380 {lab=col[9]}
N 4310 -6440 4310 -6390 {lab=col[9]}
N 4300 -6380 4300 -6140 {lab=col_n[9]}
N 4290 -6390 4300 -6380 {lab=col_n[9]}
N 4290 -6400 4290 -6390 {lab=col_n[9]}
N 4640 -6440 4640 -6400 {lab=col_n[10]}
N 4670 -6380 4670 -6140 {lab=col[10]}
N 4660 -6390 4670 -6380 {lab=col[10]}
N 4660 -6440 4660 -6390 {lab=col[10]}
N 4650 -6380 4650 -6140 {lab=col_n[10]}
N 4640 -6390 4650 -6380 {lab=col_n[10]}
N 4640 -6400 4640 -6390 {lab=col_n[10]}
N 4990 -6440 4990 -6400 {lab=col_n[11]}
N 5020 -6380 5020 -6140 {lab=col[11]}
N 5010 -6390 5020 -6380 {lab=col[11]}
N 5010 -6440 5010 -6390 {lab=col[11]}
N 5000 -6380 5000 -6140 {lab=col_n[11]}
N 4990 -6390 5000 -6380 {lab=col_n[11]}
N 4990 -6400 4990 -6390 {lab=col_n[11]}
N 5330 -6440 5330 -6400 {lab=col_n[12]}
N 5360 -6380 5360 -6140 {lab=col[12]}
N 5350 -6390 5360 -6380 {lab=col[12]}
N 5350 -6440 5350 -6390 {lab=col[12]}
N 5340 -6380 5340 -6140 {lab=col_n[12]}
N 5330 -6390 5340 -6380 {lab=col_n[12]}
N 5330 -6400 5330 -6390 {lab=col_n[12]}
N 5670 -6440 5670 -6400 {lab=VDD}
N 5700 -6380 5700 -6140 {lab=VSS}
N 5690 -6390 5700 -6380 {lab=VSS}
N 5690 -6440 5690 -6390 {lab=VSS}
N 5680 -6380 5680 -6140 {lab=VDD}
N 5670 -6390 5680 -6380 {lab=VDD}
N 5670 -6400 5670 -6390 {lab=VDD}
N 5690 -6130 5700 -6140 {lab=VSS}
N 5670 -6130 5680 -6140 {lab=VDD}
N 5350 -6130 5360 -6140 {lab=col[12]}
N 5330 -6130 5340 -6140 {lab=col_n[12]}
N 5010 -6130 5020 -6140 {lab=col[11]}
N 4990 -6130 5000 -6140 {lab=col_n[11]}
N 4660 -6130 4670 -6140 {lab=col[10]}
N 4640 -6130 4650 -6140 {lab=col_n[10]}
N 4310 -6130 4320 -6140 {lab=col[9]}
N 4290 -6130 4300 -6140 {lab=col_n[9]}
N 3980 -6130 3990 -6140 {lab=col[8]}
N 3960 -6130 3970 -6140 {lab=col_n[8]}
N 3650 -6130 3660 -6140 {lab=col[7]}
N 3630 -6130 3640 -6140 {lab=col_n[7]}
N 3290 -6130 3300 -6140 {lab=col[6]}
N 3270 -6130 3280 -6140 {lab=col_n[6]}
N 2940 -6130 2950 -6140 {lab=col[5]}
N 2920 -6130 2930 -6140 {lab=col_n[5]}
N 2600 -6130 2610 -6140 {lab=col[4]}
N 2580 -6130 2590 -6140 {lab=col_n[4]}
N 2250 -6130 2260 -6140 {lab=col[3]}
N 2230 -6130 2240 -6140 {lab=col_n[3]}
N 1900 -6130 1910 -6140 {lab=col[2]}
N 1880 -6130 1890 -6140 {lab=col_n[2]}
N 1550 -6130 1560 -6140 {lab=col[1]}
N 1530 -6130 1540 -6140 {lab=col_n[1]}
N 1220 -6130 1230 -6140 {lab=col[0]}
N 1200 -6130 1210 -6140 {lab=col_n[0]}
N 980 -3620 1080 -3620 {lab=#net21}
N 980 -3600 1080 -3600 {lab=#net22}
N 770 -3690 990 -3690 {lab=rowoff_n[0]}
N 990 -3690 1000 -3680 {lab=rowoff_n[0]}
N 1000 -3680 1080 -3680 {lab=rowoff_n[0]}
N 770 -3670 990 -3670 {lab=row_n[0]}
N 990 -3670 1000 -3660 {lab=row_n[0]}
N 1000 -3660 1080 -3660 {lab=row_n[0]}
N 770 -3650 990 -3650 {lab=rowon_n[0]}
N 990 -3650 1000 -3640 {lab=rowon_n[0]}
N 1000 -3640 1080 -3640 {lab=rowon_n[0]}
N 880 -3520 890 -3530 {lab=VDD}
N 890 -3770 890 -3530 {lab=VDD}
N 900 -3520 910 -3530 {lab=VSS}
N 910 -3770 910 -3530 {lab=VSS}
N 760 -3680 770 -3690 {lab=rowoff_n[0]}
N 760 -3660 770 -3670 {lab=row_n[0]}
N 760 -3640 770 -3650 {lab=rowon_n[0]}
N 1200 -3780 1210 -3770 {lab=col_n[0]}
N 1200 -3820 1200 -3780 {lab=col_n[0]}
N 1220 -3820 1220 -3780 {lab=col[0]}
N 1220 -3780 1230 -3770 {lab=col[0]}
N 1210 -3770 1210 -3530 {lab=col_n[0]}
N 1230 -3770 1230 -3530 {lab=col[0]}
N 1530 -3780 1540 -3770 {lab=col_n[1]}
N 1530 -3820 1530 -3780 {lab=col_n[1]}
N 1550 -3820 1550 -3780 {lab=col[1]}
N 1550 -3780 1560 -3770 {lab=col[1]}
N 1540 -3770 1540 -3530 {lab=col_n[1]}
N 1560 -3770 1560 -3530 {lab=col[1]}
N 1880 -3780 1890 -3770 {lab=col_n[2]}
N 1880 -3820 1880 -3780 {lab=col_n[2]}
N 1900 -3820 1900 -3780 {lab=col[2]}
N 1900 -3780 1910 -3770 {lab=col[2]}
N 1890 -3770 1890 -3530 {lab=col_n[2]}
N 1910 -3770 1910 -3530 {lab=col[2]}
N 2230 -3780 2240 -3770 {lab=col_n[3]}
N 2230 -3820 2230 -3780 {lab=col_n[3]}
N 2250 -3820 2250 -3780 {lab=col[3]}
N 2250 -3780 2260 -3770 {lab=col[3]}
N 2240 -3770 2240 -3530 {lab=col_n[3]}
N 2260 -3770 2260 -3530 {lab=col[3]}
N 2580 -3780 2590 -3770 {lab=col_n[4]}
N 2580 -3820 2580 -3780 {lab=col_n[4]}
N 2600 -3820 2600 -3780 {lab=col[4]}
N 2600 -3780 2610 -3770 {lab=col[4]}
N 2590 -3770 2590 -3530 {lab=col_n[4]}
N 2610 -3770 2610 -3530 {lab=col[4]}
N 2920 -3780 2930 -3770 {lab=col_n[5]}
N 2920 -3820 2920 -3780 {lab=col_n[5]}
N 2940 -3820 2940 -3780 {lab=col[5]}
N 2940 -3780 2950 -3770 {lab=col[5]}
N 2930 -3770 2930 -3530 {lab=col_n[5]}
N 2950 -3770 2950 -3530 {lab=col[5]}
N 3270 -3780 3280 -3770 {lab=col_n[6]}
N 3270 -3820 3270 -3780 {lab=col_n[6]}
N 3290 -3820 3290 -3780 {lab=col[6]}
N 3290 -3780 3300 -3770 {lab=col[6]}
N 3280 -3770 3280 -3530 {lab=col_n[6]}
N 3300 -3770 3300 -3530 {lab=col[6]}
N 3630 -3780 3640 -3770 {lab=col_n[7]}
N 3630 -3820 3630 -3780 {lab=col_n[7]}
N 3650 -3820 3650 -3780 {lab=col[7]}
N 3650 -3780 3660 -3770 {lab=col[7]}
N 3640 -3770 3640 -3530 {lab=col_n[7]}
N 3660 -3770 3660 -3530 {lab=col[7]}
N 3960 -3780 3970 -3770 {lab=col_n[8]}
N 3960 -3820 3960 -3780 {lab=col_n[8]}
N 3980 -3820 3980 -3780 {lab=col[8]}
N 3980 -3780 3990 -3770 {lab=col[8]}
N 3970 -3770 3970 -3530 {lab=col_n[8]}
N 3990 -3770 3990 -3530 {lab=col[8]}
N 4290 -3780 4300 -3770 {lab=col_n[9]}
N 4290 -3820 4290 -3780 {lab=col_n[9]}
N 4310 -3820 4310 -3780 {lab=col[9]}
N 4310 -3780 4320 -3770 {lab=col[9]}
N 4300 -3770 4300 -3530 {lab=col_n[9]}
N 4320 -3770 4320 -3530 {lab=col[9]}
N 4640 -3780 4650 -3770 {lab=col_n[10]}
N 4640 -3820 4640 -3780 {lab=col_n[10]}
N 4660 -3820 4660 -3780 {lab=col[10]}
N 4660 -3780 4670 -3770 {lab=col[10]}
N 4650 -3770 4650 -3530 {lab=col_n[10]}
N 4670 -3770 4670 -3530 {lab=col[10]}
N 4990 -3780 5000 -3770 {lab=col_n[11]}
N 4990 -3820 4990 -3780 {lab=col_n[11]}
N 5010 -3820 5010 -3780 {lab=col[11]}
N 5010 -3780 5020 -3770 {lab=col[11]}
N 5000 -3770 5000 -3530 {lab=col_n[11]}
N 5020 -3770 5020 -3530 {lab=col[11]}
N 5330 -3780 5340 -3770 {lab=col_n[12]}
N 5330 -3820 5330 -3780 {lab=col_n[12]}
N 5350 -3820 5350 -3780 {lab=col[12]}
N 5350 -3780 5360 -3770 {lab=col[12]}
N 5340 -3770 5340 -3530 {lab=col_n[12]}
N 5360 -3770 5360 -3530 {lab=col[12]}
N 5670 -3780 5680 -3770 {lab=VDD}
N 5670 -3820 5670 -3780 {lab=VDD}
N 5690 -3820 5690 -3780 {lab=VSS}
N 5690 -3780 5700 -3770 {lab=VSS}
N 5680 -3770 5680 -3530 {lab=VDD}
N 5700 -3770 5700 -3530 {lab=VSS}
N 1200 -3520 1210 -3530 {lab=col_n[0]}
N 1220 -3520 1230 -3530 {lab=col[0]}
N 1080 -3680 1090 -3690 {lab=rowoff_n[0]}
N 1090 -3690 1290 -3690 {lab=rowoff_n[0]}
N 1290 -3690 1300 -3680 {lab=rowoff_n[0]}
N 1300 -3680 1410 -3680 {lab=rowoff_n[0]}
N 1080 -3660 1090 -3670 {lab=row_n[0]}
N 1090 -3670 1290 -3670 {lab=row_n[0]}
N 1290 -3670 1300 -3660 {lab=row_n[0]}
N 1300 -3660 1410 -3660 {lab=row_n[0]}
N 1080 -3640 1090 -3650 {lab=rowon_n[0]}
N 1090 -3650 1290 -3650 {lab=rowon_n[0]}
N 1290 -3650 1300 -3640 {lab=rowon_n[0]}
N 1300 -3640 1410 -3640 {lab=rowon_n[0]}
N 1080 -3620 1090 -3630 {lab=#net21}
N 1090 -3630 1290 -3630 {lab=#net21}
N 1290 -3630 1300 -3620 {lab=#net21}
N 1300 -3620 1410 -3620 {lab=#net21}
N 1080 -3600 1090 -3610 {lab=#net22}
N 1090 -3610 1290 -3610 {lab=#net22}
N 1290 -3610 1300 -3600 {lab=#net22}
N 1300 -3600 1410 -3600 {lab=#net22}
N 1530 -3520 1540 -3530 {lab=col_n[1]}
N 1550 -3520 1560 -3530 {lab=col[1]}
N 1440 -3690 1640 -3690 {lab=rowoff_n[0]}
N 1640 -3690 1650 -3680 {lab=rowoff_n[0]}
N 1650 -3680 1760 -3680 {lab=rowoff_n[0]}
N 1440 -3670 1640 -3670 {lab=row_n[0]}
N 1640 -3670 1650 -3660 {lab=row_n[0]}
N 1650 -3660 1760 -3660 {lab=row_n[0]}
N 1440 -3650 1640 -3650 {lab=rowon_n[0]}
N 1640 -3650 1650 -3640 {lab=rowon_n[0]}
N 1650 -3640 1760 -3640 {lab=rowon_n[0]}
N 1440 -3630 1640 -3630 {lab=#net21}
N 1640 -3630 1650 -3620 {lab=#net21}
N 1650 -3620 1760 -3620 {lab=#net21}
N 1440 -3610 1640 -3610 {lab=#net22}
N 1640 -3610 1650 -3600 {lab=#net22}
N 1650 -3600 1760 -3600 {lab=#net22}
N 1410 -3680 1420 -3690 {lab=rowoff_n[0]}
N 1420 -3690 1440 -3690 {lab=rowoff_n[0]}
N 1410 -3660 1420 -3670 {lab=row_n[0]}
N 1420 -3670 1440 -3670 {lab=row_n[0]}
N 1410 -3640 1420 -3650 {lab=rowon_n[0]}
N 1420 -3650 1440 -3650 {lab=rowon_n[0]}
N 1410 -3620 1420 -3630 {lab=#net21}
N 1420 -3630 1440 -3630 {lab=#net21}
N 1410 -3600 1420 -3610 {lab=#net22}
N 1420 -3610 1440 -3610 {lab=#net22}
N 1880 -3520 1890 -3530 {lab=col_n[2]}
N 1900 -3520 1910 -3530 {lab=col[2]}
N 1790 -3690 1990 -3690 {lab=rowoff_n[0]}
N 1990 -3690 2000 -3680 {lab=rowoff_n[0]}
N 2000 -3680 2110 -3680 {lab=rowoff_n[0]}
N 1790 -3670 1990 -3670 {lab=row_n[0]}
N 1990 -3670 2000 -3660 {lab=row_n[0]}
N 2000 -3660 2110 -3660 {lab=row_n[0]}
N 1790 -3650 1990 -3650 {lab=rowon_n[0]}
N 1990 -3650 2000 -3640 {lab=rowon_n[0]}
N 2000 -3640 2110 -3640 {lab=rowon_n[0]}
N 1790 -3630 1990 -3630 {lab=#net21}
N 1990 -3630 2000 -3620 {lab=#net21}
N 2000 -3620 2110 -3620 {lab=#net21}
N 1790 -3610 1990 -3610 {lab=#net22}
N 1990 -3610 2000 -3600 {lab=#net22}
N 2000 -3600 2110 -3600 {lab=#net22}
N 1760 -3680 1770 -3690 {lab=rowoff_n[0]}
N 1770 -3690 1790 -3690 {lab=rowoff_n[0]}
N 1760 -3660 1770 -3670 {lab=row_n[0]}
N 1770 -3670 1790 -3670 {lab=row_n[0]}
N 1760 -3640 1770 -3650 {lab=rowon_n[0]}
N 1770 -3650 1790 -3650 {lab=rowon_n[0]}
N 1760 -3620 1770 -3630 {lab=#net21}
N 1770 -3630 1790 -3630 {lab=#net21}
N 1760 -3600 1770 -3610 {lab=#net22}
N 1770 -3610 1790 -3610 {lab=#net22}
N 2230 -3520 2240 -3530 {lab=col_n[3]}
N 2250 -3520 2260 -3530 {lab=col[3]}
N 2580 -3520 2590 -3530 {lab=col_n[4]}
N 2600 -3520 2610 -3530 {lab=col[4]}
N 2110 -3680 2120 -3690 {lab=rowoff_n[0]}
N 2120 -3690 2140 -3690 {lab=rowoff_n[0]}
N 2110 -3660 2120 -3670 {lab=row_n[0]}
N 2120 -3670 2140 -3670 {lab=row_n[0]}
N 2110 -3640 2120 -3650 {lab=rowon_n[0]}
N 2120 -3650 2140 -3650 {lab=rowon_n[0]}
N 2110 -3620 2120 -3630 {lab=#net21}
N 2120 -3630 2140 -3630 {lab=#net21}
N 2110 -3600 2120 -3610 {lab=#net22}
N 2120 -3610 2140 -3610 {lab=#net22}
N 2140 -3690 2320 -3690 {lab=rowoff_n[0]}
N 2320 -3690 2330 -3680 {lab=rowoff_n[0]}
N 2330 -3680 2460 -3680 {lab=rowoff_n[0]}
N 2140 -3670 2320 -3670 {lab=row_n[0]}
N 2320 -3670 2330 -3660 {lab=row_n[0]}
N 2330 -3660 2460 -3660 {lab=row_n[0]}
N 2140 -3650 2320 -3650 {lab=rowon_n[0]}
N 2320 -3650 2330 -3640 {lab=rowon_n[0]}
N 2330 -3640 2460 -3640 {lab=rowon_n[0]}
N 2140 -3630 2320 -3630 {lab=#net21}
N 2140 -3610 2320 -3610 {lab=#net22}
N 2320 -3610 2330 -3600 {lab=#net22}
N 2330 -3600 2460 -3600 {lab=#net22}
N 2330 -3620 2460 -3620 {lab=#net21}
N 2320 -3630 2330 -3620 {lab=#net21}
N 2920 -3520 2930 -3530 {lab=col_n[5]}
N 2940 -3520 2950 -3530 {lab=col[5]}
N 2460 -3680 2470 -3690 {lab=rowoff_n[0]}
N 2470 -3690 2670 -3690 {lab=rowoff_n[0]}
N 2460 -3660 2470 -3670 {lab=row_n[0]}
N 2470 -3670 2670 -3670 {lab=row_n[0]}
N 2670 -3670 2680 -3660 {lab=row_n[0]}
N 2680 -3660 2800 -3660 {lab=row_n[0]}
N 2670 -3690 2680 -3680 {lab=rowoff_n[0]}
N 2680 -3680 2800 -3680 {lab=rowoff_n[0]}
N 2460 -3640 2470 -3650 {lab=rowon_n[0]}
N 2470 -3650 2670 -3650 {lab=rowon_n[0]}
N 2670 -3650 2680 -3640 {lab=rowon_n[0]}
N 2680 -3640 2800 -3640 {lab=rowon_n[0]}
N 2460 -3620 2470 -3630 {lab=#net21}
N 2470 -3630 2670 -3630 {lab=#net21}
N 2670 -3630 2680 -3620 {lab=#net21}
N 2680 -3620 2800 -3620 {lab=#net21}
N 2460 -3600 2470 -3610 {lab=#net22}
N 2470 -3610 2670 -3610 {lab=#net22}
N 2670 -3610 2680 -3600 {lab=#net22}
N 2680 -3600 2800 -3600 {lab=#net22}
N 2800 -3680 2810 -3690 {lab=rowoff_n[0]}
N 2810 -3690 3010 -3690 {lab=rowoff_n[0]}
N 2800 -3660 2810 -3670 {lab=row_n[0]}
N 2810 -3670 3010 -3670 {lab=row_n[0]}
N 3010 -3670 3020 -3660 {lab=row_n[0]}
N 3020 -3660 3150 -3660 {lab=row_n[0]}
N 3020 -3680 3150 -3680 {lab=rowoff_n[0]}
N 3010 -3690 3020 -3680 {lab=rowoff_n[0]}
N 2800 -3640 2810 -3650 {lab=rowon_n[0]}
N 2810 -3650 3010 -3650 {lab=rowon_n[0]}
N 3010 -3650 3020 -3640 {lab=rowon_n[0]}
N 3020 -3640 3150 -3640 {lab=rowon_n[0]}
N 2800 -3620 2810 -3630 {lab=#net21}
N 2810 -3630 3010 -3630 {lab=#net21}
N 3010 -3630 3020 -3620 {lab=#net21}
N 3020 -3620 3150 -3620 {lab=#net21}
N 2800 -3600 2810 -3610 {lab=#net22}
N 2810 -3610 3010 -3610 {lab=#net22}
N 3010 -3610 3020 -3600 {lab=#net22}
N 3020 -3600 3150 -3600 {lab=#net22}
N 3270 -3520 3280 -3530 {lab=col_n[6]}
N 3290 -3520 3300 -3530 {lab=col[6]}
N 3150 -3680 3160 -3690 {lab=rowoff_n[0]}
N 3160 -3690 3360 -3690 {lab=rowoff_n[0]}
N 3360 -3690 3370 -3680 {lab=rowoff_n[0]}
N 3370 -3680 3510 -3680 {lab=rowoff_n[0]}
N 3150 -3660 3160 -3670 {lab=row_n[0]}
N 3160 -3670 3360 -3670 {lab=row_n[0]}
N 3370 -3660 3510 -3660 {lab=row_n[0]}
N 3360 -3670 3370 -3660 {lab=row_n[0]}
N 3370 -3640 3510 -3640 {lab=rowon_n[0]}
N 3360 -3650 3370 -3640 {lab=rowon_n[0]}
N 3160 -3650 3360 -3650 {lab=rowon_n[0]}
N 3150 -3640 3160 -3650 {lab=rowon_n[0]}
N 3150 -3620 3160 -3630 {lab=#net21}
N 3160 -3630 3360 -3630 {lab=#net21}
N 3360 -3630 3370 -3620 {lab=#net21}
N 3370 -3620 3510 -3620 {lab=#net21}
N 3150 -3600 3160 -3610 {lab=#net22}
N 3160 -3610 3360 -3610 {lab=#net22}
N 3360 -3610 3370 -3600 {lab=#net22}
N 3370 -3600 3510 -3600 {lab=#net22}
N 3630 -3520 3640 -3530 {lab=col_n[7]}
N 3650 -3520 3660 -3530 {lab=col[7]}
N 3510 -3680 3520 -3690 {lab=rowoff_n[0]}
N 3520 -3690 3720 -3690 {lab=rowoff_n[0]}
N 3720 -3690 3730 -3680 {lab=rowoff_n[0]}
N 3730 -3680 3840 -3680 {lab=rowoff_n[0]}
N 3510 -3660 3520 -3670 {lab=row_n[0]}
N 3520 -3670 3720 -3670 {lab=row_n[0]}
N 3720 -3670 3730 -3660 {lab=row_n[0]}
N 3730 -3660 3840 -3660 {lab=row_n[0]}
N 3510 -3640 3520 -3650 {lab=rowon_n[0]}
N 3520 -3650 3720 -3650 {lab=rowon_n[0]}
N 3720 -3650 3730 -3640 {lab=rowon_n[0]}
N 3730 -3640 3840 -3640 {lab=rowon_n[0]}
N 3510 -3620 3520 -3630 {lab=#net21}
N 3520 -3630 3720 -3630 {lab=#net21}
N 3720 -3630 3730 -3620 {lab=#net21}
N 3730 -3620 3840 -3620 {lab=#net21}
N 3510 -3600 3520 -3610 {lab=#net22}
N 3520 -3610 3720 -3610 {lab=#net22}
N 3720 -3610 3730 -3600 {lab=#net22}
N 3730 -3600 3840 -3600 {lab=#net22}
N 3960 -3520 3970 -3530 {lab=col_n[8]}
N 3980 -3520 3990 -3530 {lab=col[8]}
N 4290 -3520 4300 -3530 {lab=col_n[9]}
N 4310 -3520 4320 -3530 {lab=col[9]}
N 3840 -3680 3850 -3690 {lab=rowoff_n[0]}
N 3850 -3690 4050 -3690 {lab=rowoff_n[0]}
N 4050 -3690 4060 -3680 {lab=rowoff_n[0]}
N 4060 -3680 4170 -3680 {lab=rowoff_n[0]}
N 4060 -3660 4170 -3660 {lab=row_n[0]}
N 4050 -3670 4060 -3660 {lab=row_n[0]}
N 3850 -3670 4050 -3670 {lab=row_n[0]}
N 3840 -3660 3850 -3670 {lab=row_n[0]}
N 3840 -3640 3850 -3650 {lab=rowon_n[0]}
N 3850 -3650 4050 -3650 {lab=rowon_n[0]}
N 4050 -3650 4060 -3640 {lab=rowon_n[0]}
N 4060 -3640 4170 -3640 {lab=rowon_n[0]}
N 4060 -3620 4170 -3620 {lab=#net21}
N 4050 -3630 4060 -3620 {lab=#net21}
N 3850 -3630 4050 -3630 {lab=#net21}
N 3840 -3620 3850 -3630 {lab=#net21}
N 3840 -3600 3850 -3610 {lab=#net22}
N 3850 -3610 4050 -3610 {lab=#net22}
N 4050 -3610 4060 -3600 {lab=#net22}
N 4060 -3600 4170 -3600 {lab=#net22}
N 4170 -3680 4180 -3690 {lab=rowoff_n[0]}
N 4180 -3690 4380 -3690 {lab=rowoff_n[0]}
N 4380 -3690 4390 -3680 {lab=rowoff_n[0]}
N 4390 -3680 4520 -3680 {lab=rowoff_n[0]}
N 4390 -3660 4520 -3660 {lab=row_n[0]}
N 4380 -3670 4390 -3660 {lab=row_n[0]}
N 4180 -3670 4380 -3670 {lab=row_n[0]}
N 4170 -3660 4180 -3670 {lab=row_n[0]}
N 4170 -3640 4180 -3650 {lab=rowon_n[0]}
N 4180 -3650 4380 -3650 {lab=rowon_n[0]}
N 4380 -3650 4390 -3640 {lab=rowon_n[0]}
N 4390 -3640 4520 -3640 {lab=rowon_n[0]}
N 4390 -3620 4520 -3620 {lab=#net21}
N 4380 -3630 4390 -3620 {lab=#net21}
N 4180 -3630 4380 -3630 {lab=#net21}
N 4170 -3620 4180 -3630 {lab=#net21}
N 4170 -3600 4180 -3610 {lab=#net22}
N 4180 -3610 4380 -3610 {lab=#net22}
N 4380 -3610 4390 -3600 {lab=#net22}
N 4390 -3600 4520 -3600 {lab=#net22}
N 4520 -3680 4530 -3690 {lab=rowoff_n[0]}
N 4530 -3690 4730 -3690 {lab=rowoff_n[0]}
N 4730 -3690 4740 -3680 {lab=rowoff_n[0]}
N 4740 -3680 4870 -3680 {lab=rowoff_n[0]}
N 4520 -3660 4530 -3670 {lab=row_n[0]}
N 4530 -3670 4730 -3670 {lab=row_n[0]}
N 4730 -3670 4740 -3660 {lab=row_n[0]}
N 4740 -3660 4870 -3660 {lab=row_n[0]}
N 4520 -3640 4530 -3650 {lab=rowon_n[0]}
N 4530 -3650 4730 -3650 {lab=rowon_n[0]}
N 4730 -3650 4740 -3640 {lab=rowon_n[0]}
N 4740 -3640 4870 -3640 {lab=rowon_n[0]}
N 4520 -3620 4530 -3630 {lab=#net21}
N 4530 -3630 4730 -3630 {lab=#net21}
N 4730 -3630 4740 -3620 {lab=#net21}
N 4740 -3620 4870 -3620 {lab=#net21}
N 4520 -3600 4530 -3610 {lab=#net22}
N 4530 -3610 4730 -3610 {lab=#net22}
N 4730 -3610 4740 -3600 {lab=#net22}
N 4740 -3600 4870 -3600 {lab=#net22}
N 4640 -3520 4650 -3530 {lab=col_n[10]}
N 4660 -3520 4670 -3530 {lab=col[10]}
N 4990 -3520 5000 -3530 {lab=col_n[11]}
N 5010 -3520 5020 -3530 {lab=col[11]}
N 4870 -3680 4880 -3690 {lab=rowoff_n[0]}
N 4880 -3690 5080 -3690 {lab=rowoff_n[0]}
N 5080 -3690 5090 -3680 {lab=rowoff_n[0]}
N 5090 -3680 5210 -3680 {lab=rowoff_n[0]}
N 4870 -3660 4880 -3670 {lab=row_n[0]}
N 4880 -3670 5080 -3670 {lab=row_n[0]}
N 5080 -3670 5090 -3660 {lab=row_n[0]}
N 5090 -3660 5210 -3660 {lab=row_n[0]}
N 4870 -3640 4880 -3650 {lab=rowon_n[0]}
N 4880 -3650 5080 -3650 {lab=rowon_n[0]}
N 5080 -3650 5090 -3640 {lab=rowon_n[0]}
N 5090 -3640 5210 -3640 {lab=rowon_n[0]}
N 4870 -3620 4880 -3630 {lab=#net21}
N 4880 -3630 5080 -3630 {lab=#net21}
N 5080 -3630 5090 -3620 {lab=#net21}
N 5090 -3620 5210 -3620 {lab=#net21}
N 4870 -3600 4880 -3610 {lab=#net22}
N 4880 -3610 5080 -3610 {lab=#net22}
N 5080 -3610 5090 -3600 {lab=#net22}
N 5090 -3600 5210 -3600 {lab=#net22}
N 5210 -3680 5220 -3690 {lab=rowoff_n[0]}
N 5220 -3690 5420 -3690 {lab=rowoff_n[0]}
N 5420 -3690 5430 -3680 {lab=rowoff_n[0]}
N 5430 -3680 5550 -3680 {lab=rowoff_n[0]}
N 5210 -3660 5220 -3670 {lab=row_n[0]}
N 5220 -3670 5420 -3670 {lab=row_n[0]}
N 5420 -3670 5430 -3660 {lab=row_n[0]}
N 5430 -3660 5550 -3660 {lab=row_n[0]}
N 5210 -3640 5220 -3650 {lab=rowon_n[0]}
N 5220 -3650 5420 -3650 {lab=rowon_n[0]}
N 5420 -3650 5430 -3640 {lab=rowon_n[0]}
N 5430 -3640 5550 -3640 {lab=rowon_n[0]}
N 5210 -3620 5220 -3630 {lab=#net21}
N 5220 -3630 5420 -3630 {lab=#net21}
N 5420 -3630 5430 -3620 {lab=#net21}
N 5430 -3620 5550 -3620 {lab=#net21}
N 5210 -3600 5220 -3610 {lab=#net22}
N 5220 -3610 5420 -3610 {lab=#net22}
N 5420 -3610 5430 -3600 {lab=#net22}
N 5430 -3600 5550 -3600 {lab=#net22}
N 5330 -3520 5340 -3530 {lab=col_n[12]}
N 5350 -3520 5360 -3530 {lab=col[12]}
N 5670 -3520 5680 -3530 {lab=VDD}
N 5690 -3520 5700 -3530 {lab=VSS}
N 5550 -3680 5560 -3690 {lab=rowoff_n[0]}
N 5560 -3690 5760 -3690 {lab=rowoff_n[0]}
N 5760 -3690 5770 -3680 {lab=rowoff_n[0]}
N 5550 -3660 5560 -3670 {lab=row_n[0]}
N 5560 -3670 5760 -3670 {lab=row_n[0]}
N 5760 -3670 5770 -3660 {lab=row_n[0]}
N 5550 -3640 5560 -3650 {lab=rowon_n[0]}
N 5560 -3650 5760 -3650 {lab=rowon_n[0]}
N 5760 -3650 5770 -3640 {lab=rowon_n[0]}
N 5550 -3620 5560 -3630 {lab=#net21}
N 5560 -3630 5760 -3630 {lab=#net21}
N 5760 -3630 5770 -3620 {lab=#net21}
N 5550 -3600 5560 -3610 {lab=#net22}
N 5560 -3610 5760 -3610 {lab=#net22}
N 5760 -3610 5770 -3600 {lab=#net22}
N 880 -3200 890 -3210 {lab=VDD}
N 890 -3470 890 -3210 {lab=VDD}
N 880 -3480 890 -3470 {lab=VDD}
N 880 -3520 880 -3480 {lab=VDD}
N 900 -3200 910 -3210 {lab=VSS}
N 910 -3470 910 -3210 {lab=VSS}
N 900 -3480 910 -3470 {lab=VSS}
N 900 -3520 900 -3480 {lab=VSS}
N 1210 -3470 1210 -3210 {lab=col_n[0]}
N 1200 -3480 1210 -3470 {lab=col_n[0]}
N 1200 -3520 1200 -3480 {lab=col_n[0]}
N 1230 -3470 1230 -3210 {lab=col[0]}
N 1220 -3480 1230 -3470 {lab=col[0]}
N 1220 -3520 1220 -3480 {lab=col[0]}
N 1540 -3470 1540 -3210 {lab=col_n[1]}
N 1530 -3480 1540 -3470 {lab=col_n[1]}
N 1530 -3520 1530 -3480 {lab=col_n[1]}
N 1560 -3470 1560 -3210 {lab=col[1]}
N 1550 -3480 1560 -3470 {lab=col[1]}
N 1550 -3520 1550 -3480 {lab=col[1]}
N 1890 -3470 1890 -3210 {lab=col_n[2]}
N 1880 -3480 1890 -3470 {lab=col_n[2]}
N 1880 -3520 1880 -3480 {lab=col_n[2]}
N 1910 -3470 1910 -3210 {lab=col[2]}
N 1900 -3480 1910 -3470 {lab=col[2]}
N 1900 -3520 1900 -3480 {lab=col[2]}
N 2240 -3470 2240 -3210 {lab=col_n[3]}
N 2230 -3480 2240 -3470 {lab=col_n[3]}
N 2230 -3520 2230 -3480 {lab=col_n[3]}
N 2260 -3470 2260 -3210 {lab=col[3]}
N 2250 -3480 2260 -3470 {lab=col[3]}
N 2250 -3520 2250 -3480 {lab=col[3]}
N 2590 -3470 2590 -3210 {lab=col_n[4]}
N 2580 -3480 2590 -3470 {lab=col_n[4]}
N 2580 -3520 2580 -3480 {lab=col_n[4]}
N 2610 -3470 2610 -3210 {lab=col[4]}
N 2600 -3480 2610 -3470 {lab=col[4]}
N 2600 -3520 2600 -3480 {lab=col[4]}
N 2930 -3470 2930 -3210 {lab=col_n[5]}
N 2920 -3480 2930 -3470 {lab=col_n[5]}
N 2920 -3520 2920 -3480 {lab=col_n[5]}
N 2950 -3470 2950 -3210 {lab=col[5]}
N 2940 -3480 2950 -3470 {lab=col[5]}
N 2940 -3520 2940 -3480 {lab=col[5]}
N 3280 -3470 3280 -3210 {lab=col_n[6]}
N 3270 -3480 3280 -3470 {lab=col_n[6]}
N 3270 -3520 3270 -3480 {lab=col_n[6]}
N 3300 -3470 3300 -3210 {lab=col[6]}
N 3290 -3480 3300 -3470 {lab=col[6]}
N 3290 -3520 3290 -3480 {lab=col[6]}
N 3640 -3470 3640 -3210 {lab=col_n[7]}
N 3630 -3480 3640 -3470 {lab=col_n[7]}
N 3630 -3520 3630 -3480 {lab=col_n[7]}
N 3660 -3470 3660 -3210 {lab=col[7]}
N 3650 -3480 3660 -3470 {lab=col[7]}
N 3650 -3520 3650 -3480 {lab=col[7]}
N 3970 -3470 3970 -3210 {lab=col_n[8]}
N 3960 -3480 3970 -3470 {lab=col_n[8]}
N 3960 -3520 3960 -3480 {lab=col_n[8]}
N 3990 -3470 3990 -3210 {lab=col[8]}
N 3980 -3480 3990 -3470 {lab=col[8]}
N 3980 -3520 3980 -3480 {lab=col[8]}
N 4300 -3470 4300 -3210 {lab=col_n[9]}
N 4290 -3480 4300 -3470 {lab=col_n[9]}
N 4290 -3520 4290 -3480 {lab=col_n[9]}
N 4320 -3470 4320 -3210 {lab=col[9]}
N 4310 -3480 4320 -3470 {lab=col[9]}
N 4310 -3520 4310 -3480 {lab=col[9]}
N 4650 -3470 4650 -3210 {lab=col_n[10]}
N 4640 -3480 4650 -3470 {lab=col_n[10]}
N 4640 -3520 4640 -3480 {lab=col_n[10]}
N 4670 -3470 4670 -3210 {lab=col[10]}
N 4660 -3480 4670 -3470 {lab=col[10]}
N 4660 -3520 4660 -3480 {lab=col[10]}
N 5000 -3470 5000 -3210 {lab=col_n[11]}
N 4990 -3480 5000 -3470 {lab=col_n[11]}
N 4990 -3520 4990 -3480 {lab=col_n[11]}
N 5020 -3470 5020 -3210 {lab=col[11]}
N 5010 -3480 5020 -3470 {lab=col[11]}
N 5010 -3520 5010 -3480 {lab=col[11]}
N 5340 -3470 5340 -3210 {lab=col_n[12]}
N 5330 -3480 5340 -3470 {lab=col_n[12]}
N 5330 -3520 5330 -3480 {lab=col_n[12]}
N 5360 -3470 5360 -3210 {lab=col[12]}
N 5350 -3480 5360 -3470 {lab=col[12]}
N 5350 -3520 5350 -3480 {lab=col[12]}
N 5680 -3470 5680 -3210 {lab=VDD}
N 5670 -3480 5680 -3470 {lab=VDD}
N 5670 -3520 5670 -3480 {lab=VDD}
N 5700 -3470 5700 -3210 {lab=VSS}
N 5690 -3480 5700 -3470 {lab=VSS}
N 5690 -3520 5690 -3480 {lab=VSS}
N 5670 -3200 5680 -3210 {lab=VDD}
N 5690 -3200 5700 -3210 {lab=VSS}
N 980 -3300 1080 -3300 {lab=#net23}
N 980 -3280 1080 -3280 {lab=#net24}
N 1200 -3200 1210 -3210 {lab=col_n[0]}
N 1220 -3200 1230 -3210 {lab=col[0]}
N 760 -3360 770 -3370 {lab=VDD}
N 770 -3370 970 -3370 {lab=VDD}
N 970 -3370 980 -3360 {lab=VDD}
N 980 -3360 1080 -3360 {lab=VDD}
N 760 -3340 770 -3350 {lab=VDD}
N 770 -3350 970 -3350 {lab=VDD}
N 970 -3350 980 -3340 {lab=VDD}
N 980 -3340 1080 -3340 {lab=VDD}
N 760 -3320 770 -3330 {lab=VSS}
N 770 -3330 970 -3330 {lab=VSS}
N 970 -3330 980 -3320 {lab=VSS}
N 980 -3320 1080 -3320 {lab=VSS}
N 1530 -3200 1540 -3210 {lab=col_n[1]}
N 1550 -3200 1560 -3210 {lab=col[1]}
N 1080 -3360 1090 -3370 {lab=VDD}
N 1090 -3370 1290 -3370 {lab=VDD}
N 1290 -3370 1300 -3360 {lab=VDD}
N 1300 -3360 1410 -3360 {lab=VDD}
N 1080 -3340 1090 -3350 {lab=VDD}
N 1090 -3350 1290 -3350 {lab=VDD}
N 1290 -3350 1300 -3340 {lab=VDD}
N 1300 -3340 1410 -3340 {lab=VDD}
N 1080 -3320 1090 -3330 {lab=VSS}
N 1090 -3330 1290 -3330 {lab=VSS}
N 1290 -3330 1300 -3320 {lab=VSS}
N 1300 -3320 1410 -3320 {lab=VSS}
N 1080 -3300 1090 -3310 {lab=#net23}
N 1090 -3310 1290 -3310 {lab=#net23}
N 1290 -3310 1300 -3300 {lab=#net23}
N 1300 -3300 1410 -3300 {lab=#net23}
N 1080 -3280 1090 -3290 {lab=#net24}
N 1090 -3290 1290 -3290 {lab=#net24}
N 1290 -3290 1300 -3280 {lab=#net24}
N 1300 -3280 1410 -3280 {lab=#net24}
N 1880 -3200 1890 -3210 {lab=col_n[2]}
N 1900 -3200 1910 -3210 {lab=col[2]}
N 1410 -3360 1420 -3370 {lab=VDD}
N 1420 -3370 1620 -3370 {lab=VDD}
N 1620 -3370 1630 -3360 {lab=VDD}
N 1630 -3360 1760 -3360 {lab=VDD}
N 1410 -3340 1420 -3350 {lab=VDD}
N 1420 -3350 1620 -3350 {lab=VDD}
N 1620 -3350 1630 -3340 {lab=VDD}
N 1410 -3320 1420 -3330 {lab=VSS}
N 1420 -3330 1620 -3330 {lab=VSS}
N 1620 -3330 1630 -3320 {lab=VSS}
N 1630 -3320 1760 -3320 {lab=VSS}
N 1630 -3340 1760 -3340 {lab=VDD}
N 1410 -3300 1420 -3310 {lab=#net23}
N 1420 -3310 1620 -3310 {lab=#net23}
N 1620 -3310 1630 -3300 {lab=#net23}
N 1630 -3300 1760 -3300 {lab=#net23}
N 1410 -3280 1420 -3290 {lab=#net24}
N 1420 -3290 1620 -3290 {lab=#net24}
N 1620 -3290 1630 -3280 {lab=#net24}
N 1630 -3280 1760 -3280 {lab=#net24}
N 2230 -3200 2240 -3210 {lab=col_n[3]}
N 2250 -3200 2260 -3210 {lab=col[3]}
N 1760 -3360 1770 -3370 {lab=VDD}
N 1770 -3370 1970 -3370 {lab=VDD}
N 1970 -3370 1980 -3360 {lab=VDD}
N 1980 -3360 2110 -3360 {lab=VDD}
N 1760 -3340 1770 -3350 {lab=VDD}
N 1770 -3350 1970 -3350 {lab=VDD}
N 1970 -3350 1980 -3340 {lab=VDD}
N 1980 -3340 2110 -3340 {lab=VDD}
N 1760 -3320 1770 -3330 {lab=VSS}
N 1770 -3330 1970 -3330 {lab=VSS}
N 1970 -3330 1980 -3320 {lab=VSS}
N 1980 -3320 2110 -3320 {lab=VSS}
N 1760 -3300 1770 -3310 {lab=#net23}
N 1770 -3310 1970 -3310 {lab=#net23}
N 1970 -3310 1980 -3300 {lab=#net23}
N 1980 -3300 2110 -3300 {lab=#net23}
N 1760 -3280 1770 -3290 {lab=#net24}
N 1770 -3290 1970 -3290 {lab=#net24}
N 1970 -3290 1980 -3280 {lab=#net24}
N 1980 -3280 2110 -3280 {lab=#net24}
N 2580 -3200 2590 -3210 {lab=col_n[4]}
N 2600 -3200 2610 -3210 {lab=col[4]}
N 2110 -3360 2120 -3370 {lab=VDD}
N 2120 -3370 2320 -3370 {lab=VDD}
N 2320 -3370 2330 -3360 {lab=VDD}
N 2330 -3360 2460 -3360 {lab=VDD}
N 2110 -3340 2120 -3350 {lab=VDD}
N 2120 -3350 2320 -3350 {lab=VDD}
N 2320 -3350 2330 -3340 {lab=VDD}
N 2330 -3340 2460 -3340 {lab=VDD}
N 2110 -3320 2120 -3330 {lab=VSS}
N 2120 -3330 2320 -3330 {lab=VSS}
N 2320 -3330 2330 -3320 {lab=VSS}
N 2330 -3320 2460 -3320 {lab=VSS}
N 2110 -3300 2120 -3310 {lab=#net23}
N 2120 -3310 2320 -3310 {lab=#net23}
N 2320 -3310 2330 -3300 {lab=#net23}
N 2330 -3300 2460 -3300 {lab=#net23}
N 2110 -3280 2120 -3290 {lab=#net24}
N 2120 -3290 2320 -3290 {lab=#net24}
N 2320 -3290 2330 -3280 {lab=#net24}
N 2330 -3280 2460 -3280 {lab=#net24}
N 2460 -3360 2470 -3370 {lab=VDD}
N 2470 -3370 2670 -3370 {lab=VDD}
N 2670 -3370 2680 -3360 {lab=VDD}
N 2680 -3360 2800 -3360 {lab=VDD}
N 2460 -3340 2470 -3350 {lab=VDD}
N 2470 -3350 2670 -3350 {lab=VDD}
N 2670 -3350 2680 -3340 {lab=VDD}
N 2680 -3340 2800 -3340 {lab=VDD}
N 2460 -3320 2470 -3330 {lab=VSS}
N 2470 -3330 2670 -3330 {lab=VSS}
N 2670 -3330 2680 -3320 {lab=VSS}
N 2680 -3320 2800 -3320 {lab=VSS}
N 2460 -3300 2470 -3310 {lab=#net23}
N 2470 -3310 2670 -3310 {lab=#net23}
N 2670 -3310 2680 -3300 {lab=#net23}
N 2680 -3300 2800 -3300 {lab=#net23}
N 2460 -3280 2470 -3290 {lab=#net24}
N 2470 -3290 2670 -3290 {lab=#net24}
N 2670 -3290 2680 -3280 {lab=#net24}
N 2680 -3280 2800 -3280 {lab=#net24}
N 2920 -3200 2930 -3210 {lab=col_n[5]}
N 2940 -3200 2950 -3210 {lab=col[5]}
N 2800 -3360 2810 -3370 {lab=VDD}
N 2810 -3370 3010 -3370 {lab=VDD}
N 3010 -3370 3020 -3360 {lab=VDD}
N 3020 -3360 3150 -3360 {lab=VDD}
N 2810 -3350 3010 -3350 {lab=VDD}
N 3010 -3350 3020 -3340 {lab=VDD}
N 3020 -3340 3150 -3340 {lab=VDD}
N 2810 -3330 3010 -3330 {lab=VSS}
N 3010 -3330 3020 -3320 {lab=VSS}
N 3020 -3320 3150 -3320 {lab=VSS}
N 2810 -3310 3010 -3310 {lab=#net23}
N 3010 -3310 3020 -3300 {lab=#net23}
N 3020 -3300 3150 -3300 {lab=#net23}
N 2810 -3290 3010 -3290 {lab=#net24}
N 3010 -3290 3020 -3280 {lab=#net24}
N 3020 -3280 3150 -3280 {lab=#net24}
N 2800 -3340 2810 -3350 {lab=VDD}
N 2800 -3320 2810 -3330 {lab=VSS}
N 2800 -3300 2810 -3310 {lab=#net23}
N 2800 -3280 2810 -3290 {lab=#net24}
N 3150 -3360 3160 -3370 {lab=VDD}
N 3160 -3370 3360 -3370 {lab=VDD}
N 3360 -3370 3370 -3360 {lab=VDD}
N 3370 -3360 3510 -3360 {lab=VDD}
N 3150 -3340 3160 -3350 {lab=VDD}
N 3160 -3350 3360 -3350 {lab=VDD}
N 3360 -3350 3370 -3340 {lab=VDD}
N 3370 -3340 3510 -3340 {lab=VDD}
N 3150 -3320 3160 -3330 {lab=VSS}
N 3160 -3330 3360 -3330 {lab=VSS}
N 3360 -3330 3370 -3320 {lab=VSS}
N 3370 -3320 3510 -3320 {lab=VSS}
N 3150 -3300 3160 -3310 {lab=#net23}
N 3160 -3310 3360 -3310 {lab=#net23}
N 3360 -3310 3370 -3300 {lab=#net23}
N 3370 -3300 3510 -3300 {lab=#net23}
N 3150 -3280 3160 -3290 {lab=#net24}
N 3160 -3290 3360 -3290 {lab=#net24}
N 3360 -3290 3370 -3280 {lab=#net24}
N 3370 -3280 3510 -3280 {lab=#net24}
N 3270 -3200 3280 -3210 {lab=col_n[6]}
N 3290 -3200 3300 -3210 {lab=col[6]}
N 3630 -3200 3640 -3210 {lab=col_n[7]}
N 3650 -3200 3660 -3210 {lab=col[7]}
N 3510 -3360 3520 -3370 {lab=VDD}
N 3520 -3370 3720 -3370 {lab=VDD}
N 3720 -3370 3730 -3360 {lab=VDD}
N 3730 -3360 3840 -3360 {lab=VDD}
N 3510 -3340 3520 -3350 {lab=VDD}
N 3520 -3350 3720 -3350 {lab=VDD}
N 3720 -3350 3730 -3340 {lab=VDD}
N 3730 -3340 3840 -3340 {lab=VDD}
N 3510 -3320 3520 -3330 {lab=VSS}
N 3520 -3330 3720 -3330 {lab=VSS}
N 3720 -3330 3730 -3320 {lab=VSS}
N 3730 -3320 3840 -3320 {lab=VSS}
N 3510 -3300 3520 -3310 {lab=#net23}
N 3520 -3310 3720 -3310 {lab=#net23}
N 3720 -3310 3730 -3300 {lab=#net23}
N 3730 -3300 3840 -3300 {lab=#net23}
N 3510 -3280 3520 -3290 {lab=#net24}
N 3520 -3290 3720 -3290 {lab=#net24}
N 3720 -3290 3730 -3280 {lab=#net24}
N 3730 -3280 3840 -3280 {lab=#net24}
N 3840 -3360 3850 -3370 {lab=VDD}
N 3850 -3370 4050 -3370 {lab=VDD}
N 4050 -3370 4060 -3360 {lab=VDD}
N 4060 -3360 4170 -3360 {lab=VDD}
N 3960 -3200 3970 -3210 {lab=col_n[8]}
N 3980 -3200 3990 -3210 {lab=col[8]}
N 3840 -3340 3850 -3350 {lab=VDD}
N 3850 -3350 4050 -3350 {lab=VDD}
N 4050 -3350 4060 -3340 {lab=VDD}
N 4060 -3340 4170 -3340 {lab=VDD}
N 3840 -3320 3850 -3330 {lab=VSS}
N 3850 -3330 4050 -3330 {lab=VSS}
N 4050 -3330 4060 -3320 {lab=VSS}
N 4060 -3320 4170 -3320 {lab=VSS}
N 3840 -3300 3850 -3310 {lab=#net23}
N 3850 -3310 4050 -3310 {lab=#net23}
N 4050 -3310 4060 -3300 {lab=#net23}
N 4060 -3300 4170 -3300 {lab=#net23}
N 3840 -3280 3850 -3290 {lab=#net24}
N 3850 -3290 4050 -3290 {lab=#net24}
N 4050 -3290 4060 -3280 {lab=#net24}
N 4060 -3280 4170 -3280 {lab=#net24}
N 4290 -3200 4300 -3210 {lab=col_n[9]}
N 4310 -3200 4320 -3210 {lab=col[9]}
N 4170 -3360 4180 -3370 {lab=VDD}
N 4180 -3370 4380 -3370 {lab=VDD}
N 4380 -3370 4390 -3360 {lab=VDD}
N 4390 -3360 4520 -3360 {lab=VDD}
N 4170 -3340 4180 -3350 {lab=VDD}
N 4180 -3350 4380 -3350 {lab=VDD}
N 4380 -3350 4390 -3340 {lab=VDD}
N 4390 -3340 4520 -3340 {lab=VDD}
N 4170 -3320 4180 -3330 {lab=VSS}
N 4180 -3330 4380 -3330 {lab=VSS}
N 4380 -3330 4390 -3320 {lab=VSS}
N 4390 -3320 4520 -3320 {lab=VSS}
N 4180 -3310 4380 -3310 {lab=#net23}
N 4380 -3310 4390 -3300 {lab=#net23}
N 4390 -3300 4520 -3300 {lab=#net23}
N 4180 -3290 4380 -3290 {lab=#net24}
N 4380 -3290 4390 -3280 {lab=#net24}
N 4390 -3280 4520 -3280 {lab=#net24}
N 4170 -3300 4180 -3310 {lab=#net23}
N 4170 -3280 4180 -3290 {lab=#net24}
N 4530 -3370 4730 -3370 {lab=VDD}
N 4730 -3370 4740 -3360 {lab=VDD}
N 4740 -3360 4870 -3360 {lab=VDD}
N 4530 -3350 4730 -3350 {lab=VDD}
N 4730 -3350 4740 -3340 {lab=VDD}
N 4740 -3340 4870 -3340 {lab=VDD}
N 4530 -3330 4730 -3330 {lab=VSS}
N 4730 -3330 4740 -3320 {lab=VSS}
N 4740 -3320 4870 -3320 {lab=VSS}
N 4530 -3310 4730 -3310 {lab=#net23}
N 4730 -3310 4740 -3300 {lab=#net23}
N 4740 -3300 4870 -3300 {lab=#net23}
N 4530 -3290 4730 -3290 {lab=#net24}
N 4730 -3290 4740 -3280 {lab=#net24}
N 4740 -3280 4870 -3280 {lab=#net24}
N 4640 -3200 4650 -3210 {lab=col_n[10]}
N 4660 -3200 4670 -3210 {lab=col[10]}
N 4520 -3360 4530 -3370 {lab=VDD}
N 4520 -3340 4530 -3350 {lab=VDD}
N 4520 -3320 4530 -3330 {lab=VSS}
N 4520 -3300 4530 -3310 {lab=#net23}
N 4520 -3280 4530 -3290 {lab=#net24}
N 5010 -3200 5020 -3210 {lab=col[11]}
N 4990 -3200 5000 -3210 {lab=col_n[11]}
N 4870 -3360 4880 -3370 {lab=VDD}
N 4880 -3370 5080 -3370 {lab=VDD}
N 5080 -3370 5090 -3360 {lab=VDD}
N 5090 -3360 5210 -3360 {lab=VDD}
N 4880 -3350 5080 -3350 {lab=VDD}
N 5080 -3350 5090 -3340 {lab=VDD}
N 5090 -3340 5210 -3340 {lab=VDD}
N 4880 -3330 5080 -3330 {lab=VSS}
N 5080 -3330 5090 -3320 {lab=VSS}
N 5090 -3320 5210 -3320 {lab=VSS}
N 4880 -3310 5080 -3310 {lab=#net23}
N 5080 -3310 5090 -3300 {lab=#net23}
N 5090 -3300 5210 -3300 {lab=#net23}
N 4880 -3290 5080 -3290 {lab=#net24}
N 5080 -3290 5090 -3280 {lab=#net24}
N 5090 -3280 5210 -3280 {lab=#net24}
N 4870 -3340 4880 -3350 {lab=VDD}
N 4870 -3320 4880 -3330 {lab=VSS}
N 4870 -3300 4880 -3310 {lab=#net23}
N 4870 -3280 4880 -3290 {lab=#net24}
N 5210 -3360 5220 -3370 {lab=VDD}
N 5220 -3370 5420 -3370 {lab=VDD}
N 5420 -3370 5430 -3360 {lab=VDD}
N 5430 -3360 5550 -3360 {lab=VDD}
N 5220 -3350 5420 -3350 {lab=VDD}
N 5420 -3350 5430 -3340 {lab=VDD}
N 5430 -3340 5550 -3340 {lab=VDD}
N 5220 -3330 5420 -3330 {lab=VSS}
N 5420 -3330 5430 -3320 {lab=VSS}
N 5430 -3320 5550 -3320 {lab=VSS}
N 5220 -3310 5420 -3310 {lab=#net23}
N 5420 -3310 5430 -3300 {lab=#net23}
N 5430 -3300 5550 -3300 {lab=#net23}
N 5220 -3290 5420 -3290 {lab=#net24}
N 5420 -3290 5430 -3280 {lab=#net24}
N 5430 -3280 5550 -3280 {lab=#net24}
N 5330 -3200 5340 -3210 {lab=col_n[12]}
N 5350 -3200 5360 -3210 {lab=col[12]}
N 5210 -3340 5220 -3350 {lab=VDD}
N 5210 -3320 5220 -3330 {lab=VSS}
N 5210 -3300 5220 -3310 {lab=#net23}
N 5210 -3280 5220 -3290 {lab=#net24}
N 5550 -3360 5560 -3370 {lab=VDD}
N 5560 -3370 5760 -3370 {lab=VDD}
N 5760 -3370 5770 -3360 {lab=VDD}
N 5560 -3350 5760 -3350 {lab=VDD}
N 5760 -3350 5770 -3340 {lab=VDD}
N 5560 -3330 5760 -3330 {lab=VSS}
N 5760 -3330 5770 -3320 {lab=VSS}
N 5560 -3310 5760 -3310 {lab=#net23}
N 5760 -3310 5770 -3300 {lab=#net23}
N 5560 -3290 5760 -3290 {lab=#net24}
N 5760 -3290 5770 -3280 {lab=#net24}
N 5550 -3340 5560 -3350 {lab=VDD}
N 5550 -3320 5560 -3330 {lab=VSS}
N 5550 -3300 5560 -3310 {lab=#net23}
N 5550 -3280 5560 -3290 {lab=#net24}
N 5690 -6770 5700 -6780 {lab=VSS}
N 5700 -6980 5700 -6780 {lab=VSS}
N 5690 -6990 5700 -6980 {lab=VSS}
N 5690 -7010 5690 -6990 {lab=VSS}
N 5670 -6770 5680 -6780 {lab=VDD}
N 5680 -6980 5680 -6780 {lab=VDD}
N 5670 -6990 5680 -6980 {lab=VDD}
N 5670 -7010 5670 -6990 {lab=VDD}
N 5350 -6770 5360 -6780 {lab=col[12]}
N 5360 -6980 5360 -6780 {lab=col[12]}
N 5350 -6990 5360 -6980 {lab=col[12]}
N 5350 -7010 5350 -6990 {lab=col[12]}
N 5330 -6770 5340 -6780 {lab=col_n[12]}
N 5340 -6980 5340 -6780 {lab=col_n[12]}
N 5330 -6990 5340 -6980 {lab=col_n[12]}
N 5330 -7010 5330 -6990 {lab=col_n[12]}
N 5010 -6770 5020 -6780 {lab=col[11]}
N 5020 -6980 5020 -6780 {lab=col[11]}
N 5010 -6990 5020 -6980 {lab=col[11]}
N 5010 -7010 5010 -6990 {lab=col[11]}
N 4990 -6770 5000 -6780 {lab=col_n[11]}
N 5000 -6980 5000 -6780 {lab=col_n[11]}
N 4990 -6990 5000 -6980 {lab=col_n[11]}
N 4990 -7010 4990 -6990 {lab=col_n[11]}
N 4660 -6770 4670 -6780 {lab=col[10]}
N 4670 -6980 4670 -6780 {lab=col[10]}
N 4660 -6990 4670 -6980 {lab=col[10]}
N 4660 -7010 4660 -6990 {lab=col[10]}
N 4640 -6770 4650 -6780 {lab=col_n[10]}
N 4650 -6980 4650 -6780 {lab=col_n[10]}
N 4640 -6990 4650 -6980 {lab=col_n[10]}
N 4640 -7010 4640 -6990 {lab=col_n[10]}
N 4310 -6770 4320 -6780 {lab=col[9]}
N 4320 -6980 4320 -6780 {lab=col[9]}
N 4310 -6990 4320 -6980 {lab=col[9]}
N 4310 -7010 4310 -6990 {lab=col[9]}
N 4290 -6770 4300 -6780 {lab=col_n[9]}
N 4300 -6980 4300 -6780 {lab=col_n[9]}
N 4290 -6990 4300 -6980 {lab=col_n[9]}
N 4290 -7010 4290 -6990 {lab=col_n[9]}
N 3980 -6770 3990 -6780 {lab=col[8]}
N 3990 -6980 3990 -6780 {lab=col[8]}
N 3980 -6990 3990 -6980 {lab=col[8]}
N 3980 -7010 3980 -6990 {lab=col[8]}
N 3960 -6770 3970 -6780 {lab=col_n[8]}
N 3970 -6980 3970 -6780 {lab=col_n[8]}
N 3960 -6990 3970 -6980 {lab=col_n[8]}
N 3960 -7010 3960 -6990 {lab=col_n[8]}
N 3650 -6770 3660 -6780 {lab=col[7]}
N 3660 -6980 3660 -6780 {lab=col[7]}
N 3650 -6990 3660 -6980 {lab=col[7]}
N 3650 -7010 3650 -6990 {lab=col[7]}
N 3630 -6770 3640 -6780 {lab=col_n[7]}
N 3640 -6980 3640 -6780 {lab=col_n[7]}
N 3630 -6990 3640 -6980 {lab=col_n[7]}
N 3630 -7010 3630 -6990 {lab=col_n[7]}
N 3290 -6770 3300 -6780 {lab=col[6]}
N 3300 -6980 3300 -6780 {lab=col[6]}
N 3290 -6990 3300 -6980 {lab=col[6]}
N 3290 -7010 3290 -6990 {lab=col[6]}
N 3270 -6770 3280 -6780 {lab=col_n[6]}
N 3280 -6980 3280 -6780 {lab=col_n[6]}
N 3270 -6990 3280 -6980 {lab=col_n[6]}
N 3270 -7010 3270 -6990 {lab=col_n[6]}
N 2940 -6770 2950 -6780 {lab=col[5]}
N 2950 -6980 2950 -6780 {lab=col[5]}
N 2940 -6990 2950 -6980 {lab=col[5]}
N 2940 -7010 2940 -6990 {lab=col[5]}
N 2920 -6770 2930 -6780 {lab=col_n[5]}
N 2930 -6980 2930 -6780 {lab=col_n[5]}
N 2920 -6990 2930 -6980 {lab=col_n[5]}
N 2920 -7010 2920 -6990 {lab=col_n[5]}
N 2600 -6770 2610 -6780 {lab=col[4]}
N 2610 -6980 2610 -6780 {lab=col[4]}
N 2600 -6990 2610 -6980 {lab=col[4]}
N 2600 -7010 2600 -6990 {lab=col[4]}
N 2580 -6770 2590 -6780 {lab=col_n[4]}
N 2590 -6980 2590 -6780 {lab=col_n[4]}
N 2580 -6990 2590 -6980 {lab=col_n[4]}
N 2580 -7010 2580 -6990 {lab=col_n[4]}
N 2250 -6770 2260 -6780 {lab=col[3]}
N 2260 -6980 2260 -6780 {lab=col[3]}
N 2250 -6990 2260 -6980 {lab=col[3]}
N 2250 -7010 2250 -6990 {lab=col[3]}
N 2230 -6770 2240 -6780 {lab=col_n[3]}
N 2240 -6980 2240 -6780 {lab=col_n[3]}
N 2230 -6990 2240 -6980 {lab=col_n[3]}
N 2230 -7010 2230 -6990 {lab=col_n[3]}
N 1900 -6770 1910 -6780 {lab=col[2]}
N 1910 -6980 1910 -6780 {lab=col[2]}
N 1900 -6990 1910 -6980 {lab=col[2]}
N 1900 -7010 1900 -6990 {lab=col[2]}
N 1880 -6770 1890 -6780 {lab=col_n[2]}
N 1890 -6980 1890 -6780 {lab=col_n[2]}
N 1880 -6990 1890 -6980 {lab=col_n[2]}
N 1880 -7010 1880 -6990 {lab=col_n[2]}
N 1550 -6770 1560 -6780 {lab=col[1]}
N 1560 -6980 1560 -6780 {lab=col[1]}
N 1550 -6990 1560 -6980 {lab=col[1]}
N 1550 -7010 1550 -6990 {lab=col[1]}
N 1530 -6770 1540 -6780 {lab=col_n[1]}
N 1540 -6980 1540 -6780 {lab=col_n[1]}
N 1530 -6990 1540 -6980 {lab=col_n[1]}
N 1530 -7010 1530 -6990 {lab=col_n[1]}
N 1220 -6770 1230 -6780 {lab=col[0]}
N 1230 -6980 1230 -6780 {lab=col[0]}
N 1220 -6990 1230 -6980 {lab=col[0]}
N 1220 -7010 1220 -6990 {lab=col[0]}
N 1200 -6770 1210 -6780 {lab=col_n[0]}
N 1210 -6980 1210 -6780 {lab=col_n[0]}
N 1200 -6990 1210 -6980 {lab=col_n[0]}
N 1200 -7010 1200 -6990 {lab=col_n[0]}
N 900 -6770 910 -6780 {lab=VSS}
N 910 -6980 910 -6780 {lab=VSS}
N 900 -6990 910 -6980 {lab=VSS}
N 900 -7010 900 -6990 {lab=VSS}
N 880 -6770 890 -6780 {lab=VDD}
N 890 -6980 890 -6780 {lab=VDD}
N 880 -6990 890 -6980 {lab=VDD}
N 880 -7010 880 -6990 {lab=VDD}
N 4320 -1200 4320 -1180 {lab=#net25}
N 4320 -1180 4420 -1180 {lab=#net25}
N 4420 -1200 4420 -1180 {lab=#net25}
N 4320 -1280 4320 -1260 {lab=#net26}
N 4320 -1280 4420 -1280 {lab=#net26}
N 4420 -1280 4420 -1260 {lab=#net26}
N 4370 -1300 4370 -1280 {lab=#net26}
N 4370 -1200 4370 -1180 {lab=#net25}
N 4370 -1180 4370 -1160 {lab=#net25}
C {devices/ipin.sym} 3390 -1620 0 0 {name=p20 lab=sample}
C {devices/ipin.sym} 3390 -1480 0 0 {name=p21 lab=sample_n}
C {devices/code_shown.sym} 3510 -2470 0 0 {name=NGSPICE1 only_toplevel=true
value="
.tran 0.1u 10u 0 0.05n
.save all
"}
C {adc_sar_vcm_generator.sym} 3810 -1680 0 0 {name=x111}
C {vdd.sym} 3980 -1970 0 0 {name=l32 lab=VDD}
C {gnd.sym} 3980 -1810 0 0 {name=l33 lab=GND}
C {devices/capa.sym} 4190 -1860 0 0 {name=C1
m=1
value=6p
footprint=1206
device="ceramic capacitor"}
C {gnd.sym} 4190 -1800 0 0 {name=l114 lab=GND}
C {vsource.sym} 3870 -1860 0 0 {name=V1 value="0 pulse(0 3.3 15u 10p 10p 15u 30u)" savecurrent=false}
C {gnd.sym} 3870 -1810 0 0 {name=l115 lab=GND}
C {devices/vsource.sym} 3630 -1800 0 0 {name=V2 value=3.3}
C {devices/gnd.sym} 3630 -1750 0 0 {name=l116 lab=GND}
C {devices/vdd.sym} 3630 -1850 0 0 {name=l117 lab=VDD}
C {vsource.sym} 3380 -1860 0 0 {name=V4 value="SIN(0.9 0.9 10Meg) DC 0" savecurrent=false}
C {vsource.sym} 3380 -1710 0 0 {name=V5 value=0 savecurrent=false}
C {gnd.sym} 3380 -1680 0 0 {name=l126 lab=GND}
C {vsource.sym} 3390 -1590 0 0 {name=V3 value="PULSE(0 3.3 0 0.5n 0.5n 40n 100n)
" savecurrent=false}
C {gnd.sym} 3390 -1560 0 0 {name=l127 lab=GND}
C {vsource.sym} 3390 -1450 0 0 {name=V6 value="PULSE(3.3 0 0 0.5n 0.5n 40n 100n)
" savecurrent=false}
C {gnd.sym} 3390 -1420 0 0 {name=l128 lab=GND}
C {devices/iopin.sym} 4600 -1890 2 1 {name=p4 lab=vcm}
C {devices/iopin.sym} 3380 -1890 0 0 {name=p5 lab=analog_in}
C {devices/iopin.sym} 3890 -1350 2 0 {name=p6 lab=VSS}
C {gnd.sym} 3890 -1270 0 0 {name=l132 lab=GND}
C {devices/iopin.sym} 4110 -1320 2 0 {name=p7 lab=ctop}
C {devices/ipin.sym} 3100 -1880 0 0 {name=p9 lab=sw}
C {devices/ipin.sym} 3100 -1570 0 0 {name=p10 lab=sw_n}
C {devices/vsource.sym} 3100 -1800 0 0 {name=V7 value="PULSE(0 3.3 0 0.5n 0.5n 40n 100n)"}
C {gnd.sym} 3100 -1750 0 0 {name=l133 lab=GND}
C {devices/vsource.sym} 3100 -1510 0 0 {name=V8 value="PULSE(3.3 0 0 0.5n 0.5n 40n 100n)"}
C {gnd.sym} 3100 -1460 0 0 {name=l134 lab=GND}
C {devices/ipin.sym} 2380 -2000 0 0 {name=p12 lab=row_n[0]}
C {devices/vsource.sym} 2380 -1930 0 0 {name=V9 value=0}
C {gnd.sym} 2380 -1870 0 0 {name=l280 lab=GND}
C {devices/ipin.sym} 2380 -1790 0 0 {name=p13 lab=row_n[1]}
C {devices/vsource.sym} 2380 -1720 0 0 {name=V10 value=0}
C {gnd.sym} 2380 -1660 0 0 {name=l281 lab=GND}
C {devices/ipin.sym} 2380 -1580 0 0 {name=p14 lab=row_n[2]}
C {devices/vsource.sym} 2380 -1510 0 0 {name=V11 value=3.3}
C {gnd.sym} 2380 -1450 0 0 {name=l282 lab=GND}
C {devices/ipin.sym} 2380 -1360 0 0 {name=p15 lab=row_n[3]}
C {devices/vsource.sym} 2380 -1290 0 0 {name=V12 value=3.3}
C {gnd.sym} 2380 -1230 0 0 {name=l350 lab=GND}
C {devices/ipin.sym} 2380 -1150 0 0 {name=p16 lab=row_n[4]}
C {gnd.sym} 2380 -1020 0 0 {name=l354 lab=GND}
C {devices/ipin.sym} 2580 -2000 0 0 {name=p33 lab=row_n[5]}
C {gnd.sym} 2580 -1870 0 0 {name=l355 lab=GND}
C {devices/ipin.sym} 2580 -1800 0 0 {name=p34 lab=row_n[6]}
C {gnd.sym} 2580 -1670 0 0 {name=l356 lab=GND}
C {devices/ipin.sym} 2580 -1590 0 0 {name=p35 lab=row_n[7]}
C {gnd.sym} 2580 -1460 0 0 {name=l414 lab=GND}
C {devices/ipin.sym} 2580 -1360 0 0 {name=p36 lab=row_n[8]}
C {gnd.sym} 2580 -1230 0 0 {name=l418 lab=GND}
C {devices/ipin.sym} 2580 -1150 0 0 {name=p37 lab=row_n[9]}
C {gnd.sym} 2580 -1020 0 0 {name=l419 lab=GND}
C {devices/ipin.sym} 1870 -2000 0 0 {name=p38 lab=rowon_n[0]}
C {devices/vsource.sym} 1870 -1930 0 0 {name=V19 value=3.3}
C {gnd.sym} 1870 -1870 0 0 {name=l420 lab=GND}
C {devices/ipin.sym} 1870 -1790 0 0 {name=p39 lab=rowon_n[1]}
C {devices/vsource.sym} 1870 -1720 0 0 {name=V20 value=3.3}
C {gnd.sym} 1870 -1660 0 0 {name=l488 lab=GND}
C {devices/ipin.sym} 1870 -1580 0 0 {name=p40 lab=rowon_n[2]}
C {devices/vsource.sym} 1870 -1510 0 0 {name=V21 value=0}
C {gnd.sym} 1870 -1450 0 0 {name=l492 lab=GND}
C {devices/ipin.sym} 1870 -1360 0 0 {name=p41 lab=rowon_n[3]}
C {devices/vsource.sym} 1870 -1290 0 0 {name=V22 value=0}
C {gnd.sym} 1870 -1230 0 0 {name=l493 lab=GND}
C {devices/ipin.sym} 1870 -1150 0 0 {name=p42 lab=rowon_n[4]}
C {devices/vsource.sym} 1870 -1080 0 0 {name=V23 value=0}
C {gnd.sym} 1870 -1020 0 0 {name=l494 lab=GND}
C {devices/ipin.sym} 2070 -2000 0 0 {name=p43 lab=rowon_n[5]}
C {devices/vsource.sym} 2070 -1930 0 0 {name=V24 value=0}
C {gnd.sym} 2070 -1870 0 0 {name=l552 lab=GND}
C {devices/ipin.sym} 2070 -1800 0 0 {name=p44 lab=rowon_n[6]}
C {devices/vsource.sym} 2070 -1730 0 0 {name=V25 value=0}
C {gnd.sym} 2070 -1670 0 0 {name=l556 lab=GND}
C {devices/ipin.sym} 2070 -1590 0 0 {name=p45 lab=rowon_n[7]}
C {devices/vsource.sym} 2070 -1520 0 0 {name=V26 value=0}
C {gnd.sym} 2070 -1460 0 0 {name=l557 lab=GND}
C {devices/ipin.sym} 2070 -1360 0 0 {name=p46 lab=rowon_n[8]}
C {devices/vsource.sym} 2070 -1290 0 0 {name=V27 value=0}
C {gnd.sym} 2070 -1230 0 0 {name=l558 lab=GND}
C {devices/ipin.sym} 2070 -1150 0 0 {name=p47 lab=rowon_n[9]}
C {devices/vsource.sym} 2070 -1080 0 0 {name=V28 value=0}
C {gnd.sym} 2070 -1020 0 0 {name=l626 lab=GND}
C {devices/ipin.sym} 1340 -1990 0 0 {name=p48 lab=rowoff_n[0]}
C {devices/vsource.sym} 1340 -1920 0 0 {name=V29 value=3.3}
C {gnd.sym} 1340 -1860 0 0 {name=l630 lab=GND}
C {devices/ipin.sym} 1340 -1780 0 0 {name=p49 lab=rowoff_n[1]}
C {devices/vsource.sym} 1340 -1710 0 0 {name=V30 value=3.3}
C {gnd.sym} 1340 -1650 0 0 {name=l631 lab=GND}
C {devices/ipin.sym} 1340 -1570 0 0 {name=p50 lab=rowoff_n[2]}
C {devices/vsource.sym} 1340 -1500 0 0 {name=V31 value=3.3}
C {gnd.sym} 1340 -1440 0 0 {name=l632 lab=GND}
C {devices/ipin.sym} 1340 -1350 0 0 {name=p51 lab=rowoff_n[3]}
C {devices/vsource.sym} 1340 -1280 0 0 {name=V32 value=3.3}
C {gnd.sym} 1340 -1220 0 0 {name=l690 lab=GND}
C {devices/ipin.sym} 1340 -1140 0 0 {name=p52 lab=rowoff_n[4]}
C {gnd.sym} 1340 -1010 0 0 {name=l694 lab=GND}
C {devices/ipin.sym} 1540 -1990 0 0 {name=p53 lab=rowoff_n[5]}
C {gnd.sym} 1540 -1860 0 0 {name=l695 lab=GND}
C {devices/ipin.sym} 1540 -1790 0 0 {name=p54 lab=rowoff_n[6]}
C {gnd.sym} 1540 -1660 0 0 {name=l696 lab=GND}
C {devices/ipin.sym} 1540 -1580 0 0 {name=p55 lab=rowoff_n[7]}
C {gnd.sym} 1540 -1450 0 0 {name=l764 lab=GND}
C {devices/ipin.sym} 1540 -1350 0 0 {name=p56 lab=rowoff_n[8]}
C {gnd.sym} 1540 -1220 0 0 {name=l768 lab=GND}
C {devices/ipin.sym} 1540 -1140 0 0 {name=p57 lab=rowoff_n[9]}
C {gnd.sym} 1540 -1010 0 0 {name=l769 lab=GND}
C {devices/ipin.sym} 1340 -850 0 0 {name=p58 lab=col_n[0]}
C {devices/vsource.sym} 1340 -790 0 0 {name=V39 value=0}
C {gnd.sym} 1340 -740 0 0 {name=l770 lab=GND}
C {devices/ipin.sym} 1340 -690 0 0 {name=p59 lab=col_n[1]}
C {devices/vsource.sym} 1340 -630 0 0 {name=V40 value=0}
C {gnd.sym} 1340 -580 0 0 {name=l813 lab=GND}
C {devices/ipin.sym} 1340 -520 0 0 {name=p60 lab=col_n[2]}
C {devices/vsource.sym} 1340 -460 0 0 {name=V41 value=0}
C {gnd.sym} 1340 -410 0 0 {name=l814 lab=GND}
C {devices/ipin.sym} 1340 -360 0 0 {name=p61 lab=col_n[3]}
C {devices/vsource.sym} 1340 -300 0 0 {name=V42 value=0}
C {gnd.sym} 1340 -250 0 0 {name=l815 lab=GND}
C {devices/ipin.sym} 1540 -860 0 0 {name=p62 lab=col_n[4]}
C {devices/vsource.sym} 1540 -800 0 0 {name=V43 value=0}
C {gnd.sym} 1540 -750 0 0 {name=l816 lab=GND}
C {devices/ipin.sym} 1540 -700 0 0 {name=p63 lab=col_n[5]}
C {devices/vsource.sym} 1540 -640 0 0 {name=V44 value=0}
C {gnd.sym} 1540 -590 0 0 {name=l817 lab=GND}
C {devices/ipin.sym} 1540 -530 0 0 {name=p64 lab=col_n[6]}
C {devices/vsource.sym} 1540 -470 0 0 {name=V45 value=0}
C {gnd.sym} 1540 -420 0 0 {name=l818 lab=GND}
C {devices/ipin.sym} 1540 -370 0 0 {name=p65 lab=col_n[7]}
C {devices/vsource.sym} 1540 -310 0 0 {name=V46 value=0}
C {gnd.sym} 1540 -260 0 0 {name=l819 lab=GND}
C {devices/ipin.sym} 1750 -860 0 0 {name=p66 lab=col_n[8]}
C {devices/vsource.sym} 1750 -800 0 0 {name=V47 value=0}
C {gnd.sym} 1750 -750 0 0 {name=l820 lab=GND}
C {devices/ipin.sym} 1750 -700 0 0 {name=p67 lab=col_n[9]}
C {devices/vsource.sym} 1750 -640 0 0 {name=V48 value=0}
C {gnd.sym} 1750 -590 0 0 {name=l821 lab=GND}
C {devices/ipin.sym} 1750 -530 0 0 {name=p68 lab=col_n[10]}
C {devices/vsource.sym} 1750 -470 0 0 {name=V49 value=0}
C {gnd.sym} 1750 -420 0 0 {name=l822 lab=GND}
C {devices/ipin.sym} 1750 -370 0 0 {name=p69 lab=col_n[11]}
C {devices/vsource.sym} 1750 -310 0 0 {name=V50 value=0}
C {gnd.sym} 1750 -260 0 0 {name=l823 lab=GND}
C {devices/ipin.sym} 1530 -180 0 0 {name=p71 lab=col_n[12]}
C {devices/vsource.sym} 1530 -120 0 0 {name=V52 value=0}
C {gnd.sym} 1530 -70 0 0 {name=l825 lab=GND}
C {devices/vsource.sym} 1920 -810 0 0 {name=V51 value=3.3}
C {gnd.sym} 1920 -760 0 0 {name=l824 lab=GND}
C {devices/ipin.sym} 1920 -860 0 0 {name=p70 lab=col[0]}
C {devices/vsource.sym} 1920 -660 0 0 {name=V53 value=3.3}
C {gnd.sym} 1920 -610 0 0 {name=l826 lab=GND}
C {devices/ipin.sym} 1920 -710 0 0 {name=p72 lab=col[1]}
C {devices/vsource.sym} 1920 -510 0 0 {name=V54 value=3.3}
C {gnd.sym} 1920 -460 0 0 {name=l827 lab=GND}
C {devices/ipin.sym} 1920 -560 0 0 {name=p73 lab=col[2]}
C {devices/vsource.sym} 1920 -350 0 0 {name=V55 value=3.3}
C {gnd.sym} 1920 -300 0 0 {name=l828 lab=GND}
C {devices/ipin.sym} 1920 -400 0 0 {name=p74 lab=col[3]}
C {devices/vsource.sym} 2040 -820 0 0 {name=V56 value=3.3}
C {gnd.sym} 2040 -770 0 0 {name=l829 lab=GND}
C {devices/ipin.sym} 2040 -870 0 0 {name=p75 lab=col[4]}
C {devices/vsource.sym} 2040 -660 0 0 {name=V57 value=3.3}
C {gnd.sym} 2040 -610 0 0 {name=l830 lab=GND}
C {devices/ipin.sym} 2040 -710 0 0 {name=p76 lab=col[5]}
C {devices/vsource.sym} 2040 -500 0 0 {name=V58 value=3.3}
C {gnd.sym} 2040 -450 0 0 {name=l831 lab=GND}
C {devices/ipin.sym} 2040 -550 0 0 {name=p77 lab=col[6]}
C {devices/vsource.sym} 2030 -350 0 0 {name=V59 value=3.3}
C {gnd.sym} 2030 -300 0 0 {name=l832 lab=GND}
C {devices/ipin.sym} 2030 -400 0 0 {name=p78 lab=col[7]}
C {devices/vsource.sym} 2170 -840 0 0 {name=V60 value=3.3}
C {gnd.sym} 2170 -790 0 0 {name=l833 lab=GND}
C {devices/ipin.sym} 2170 -890 0 0 {name=p79 lab=col[8]}
C {devices/vsource.sym} 2160 -670 0 0 {name=V61 value=3.3}
C {gnd.sym} 2160 -620 0 0 {name=l834 lab=GND}
C {devices/ipin.sym} 2160 -720 0 0 {name=p80 lab=col[9]}
C {devices/vsource.sym} 2160 -500 0 0 {name=V62 value=3.3}
C {gnd.sym} 2160 -450 0 0 {name=l835 lab=GND}
C {devices/ipin.sym} 2160 -550 0 0 {name=p81 lab=col[10]}
C {devices/vsource.sym} 2160 -340 0 0 {name=V63 value=3.3}
C {gnd.sym} 2160 -290 0 0 {name=l836 lab=GND}
C {devices/ipin.sym} 2160 -390 0 0 {name=p82 lab=col[11]}
C {devices/vsource.sym} 2280 -680 0 0 {name=V64 value=3.3}
C {gnd.sym} 2280 -630 0 0 {name=l837 lab=GND}
C {devices/ipin.sym} 2280 -730 0 0 {name=p83 lab=col[12]}
C {devices/vsource.sym} 3030 -1180 0 0 {name=V65 value=3.3}
C {devices/vsource.sym} 3180 -1180 0 0 {name=V66 value=3.3}
C {devices/vsource.sym} 3320 -1180 0 0 {name=V67 value=0}
C {gnd.sym} 3030 -1120 0 0 {name=l838 lab=GND}
C {gnd.sym} 3180 -1120 0 0 {name=l839 lab=GND}
C {gnd.sym} 3320 -1120 0 0 {name=l840 lab=GND}
C {devices/ipin.sym} 3030 -1230 0 0 {name=p84 lab=en_bit_n[0]}
C {devices/ipin.sym} 3180 -1230 0 0 {name=p85 lab=en_bit_n[1]}
C {devices/ipin.sym} 3320 -1230 0 0 {name=p86 lab=en_bit_n[2]}
C {devices/vsource.sym} 3490 -1180 0 0 {name=V68 value=3.3}
C {gnd.sym} 3490 -1120 0 0 {name=l841 lab=GND}
C {devices/ipin.sym} 3490 -1240 0 0 {name=p87 lab=en_C0_n}
C {devices/vsource.sym} 3890 -1320 0 0 {name=V69 value=0}
C {devices/vsource.sym} 1340 -1070 0 0 {name=V33 value=3.3}
C {devices/vsource.sym} 1540 -1070 0 0 {name=V35 value=3.3}
C {devices/vsource.sym} 1540 -1280 0 0 {name=V36 value=3.3}
C {devices/vsource.sym} 1540 -1510 0 0 {name=V37 value=3.3}
C {devices/vsource.sym} 1540 -1720 0 0 {name=V38 value=3.3}
C {devices/vsource.sym} 1540 -1920 0 0 {name=V34 value=3.3}
C {devices/vsource.sym} 2380 -1080 0 0 {name=V13 value=3.3}
C {devices/vsource.sym} 2580 -1080 0 0 {name=V14 value=3.3}
C {devices/vsource.sym} 2580 -1290 0 0 {name=V15 value=3.3}
C {devices/vsource.sym} 2580 -1520 0 0 {name=V16 value=3.3}
C {devices/vsource.sym} 2580 -1730 0 0 {name=V17 value=3.3}
C {devices/vsource.sym} 2580 -1930 0 0 {name=V18 value=3.3}
C {devices/code_shown.sym} 3470 -2310 0 0 {name=MODELS1 only_toplevel=true
format="tcleval( @value )"
value="
.include /home/tien/conda-gf180mcu-env/envs/gf180mcu-env/share/pdk/gf180mcuD/libs.tech/ngspice/design.ngspice
.lib /home/tien/conda-gf180mcu-env/envs/gf180mcu-env/share/pdk/gf180mcuD/libs.tech/ngspice/smbb000149.ngspice typical
.lib /home/tien/conda-gf180mcu-env/envs/gf180mcu-env/share/pdk/gf180mcuD/libs.tech/ngspice/sm141064.ngspice cap_mim
.lib /home/tien/conda-gf180mcu-env/envs/gf180mcu-env/share/pdk/gf180mcuD/libs.tech/ngspice/sm141064.ngspice mimcap_typical
.lib /home/tien/conda-gf180mcu-env/envs/gf180mcu-env/share/pdk/gf180mcuD/libs.tech/ngspice/sm141064.ngspice res_typical
.lib /home/tien/conda-gf180mcu-env/envs/gf180mcu-env/share/pdk/gf180mcuD/libs.tech/ngspice/sm141064.ngspice moscap_typical
.lib /home/tien/conda-gf180mcu-env/envs/gf180mcu-env/share/pdk/gf180mcuD/libs.tech/ngspice/sm141064.ngspice diode_typical
.lib /home/tien/conda-gf180mcu-env/envs/gf180mcu-env/share/pdk/gf180mcuD/libs.tech/ngspice/sm141064.ngspice typical
"}
C {devices/lab_wire.sym} 3900 -1890 0 0 {name=l118 sig_type=std_logic lab=clk}
C {devices/code_shown.sym} 3380 -2050 0 0 {name=STDCELL_MODELS only_toplevel=false 
format="tcleval( @value )"
value=".include /home/tien/conda-gf180mcu-env/envs/gf180mcu-env/share/pdk/gf180mcuD/libs.ref/gf180mcu_fd_sc_mcu7t5v0/spice/gf180mcu_fd_sc_mcu7t5v0.spice"}
C {adc_sar_noise_cell1.sym} 4320 -1690 0 0 {name=x321}
C {gnd.sym} 4470 -1800 0 0 {name=l49 lab=GND}
C {adc_sar_wafflecap_drv.sym} 520 -3150 0 0 {name=x2}
C {adc_sar_wafflecap_dummy.sym} 880 -3110 0 0 {name=x1}
C {adc_sar_wafflecap_8_1.sym} 980 -3090 0 0 {name=x3}
C {adc_sar_wafflecap_dummy.sym} 1560 -3110 0 0 {name=x4}
C {adc_sar_wafflecap_dummy.sym} 1910 -3110 0 0 {name=x5}
C {adc_sar_wafflecap_dummy.sym} 2260 -3110 0 0 {name=x6}
C {adc_sar_wafflecap_dummy.sym} 3970 -3110 0 0 {name=x11}
C {adc_sar_wafflecap_dummy.sym} 4320 -3110 0 0 {name=x12}
C {adc_sar_wafflecap_dummy.sym} 4670 -3110 0 0 {name=x13}
C {adc_sar_wafflecap_drv.sym} 520 -3470 0 0 {name=x17}
C {adc_sar_wafflecap_dummy.sym} 880 -3430 0 0 {name=x18}
C {adc_sar_wafflecap_8_8.sym} 1970 -3350 0 0 {name=x21}
C {adc_sar_wafflecap_8_8.sym} 2320 -3350 0 0 {name=x22}
C {adc_sar_wafflecap_8_8.sym} 2660 -3350 0 0 {name=x23}
C {adc_sar_wafflecap_8_8.sym} 3010 -3350 0 0 {name=x24}
C {adc_sar_wafflecap_8_8.sym} 3370 -3350 0 0 {name=x25}
C {adc_sar_wafflecap_dummy.sym} 4320 -3430 0 0 {name=x28}
C {adc_sar_wafflecap_dummy.sym} 4670 -3430 0 0 {name=x29}
C {adc_sar_wafflecap_dummy.sym} 5010 -3430 0 0 {name=x30}
C {adc_sar_wafflecap_dummy.sym} 5350 -3430 0 0 {name=x31}
C {adc_sar_wafflecap_drv.sym} 520 -3770 0 0 {name=x33}
C {adc_sar_wafflecap_8_8.sym} 940 -3650 0 0 {name=x34}
C {adc_sar_wafflecap_8_8.sym} 1270 -3650 0 0 {name=x35}
C {adc_sar_wafflecap_8_8.sym} 1620 -3650 0 0 {name=x36}
C {adc_sar_wafflecap_8_8.sym} 1970 -3650 0 0 {name=x37}
C {adc_sar_wafflecap_8_8.sym} 2320 -3650 0 0 {name=x38}
C {adc_sar_wafflecap_8_8.sym} 2660 -3650 0 0 {name=x39}
C {adc_sar_wafflecap_8_8.sym} 3010 -3650 0 0 {name=x40}
C {adc_sar_wafflecap_8_8.sym} 3370 -3650 0 0 {name=x41}
C {adc_sar_wafflecap_8_8.sym} 3700 -3650 0 0 {name=x42}
C {adc_sar_wafflecap_8_8.sym} 4030 -3650 0 0 {name=x43}
C {adc_sar_wafflecap_8_8.sym} 4380 -3650 0 0 {name=x44}
C {adc_sar_wafflecap_8_8.sym} 4730 -3650 0 0 {name=x45}
C {adc_sar_wafflecap_8_8.sym} 5070 -3650 0 0 {name=x46}
C {devices/lab_wire.sym} 740 -3320 0 0 {name=l2050 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 740 -3340 0 0 {name=l2051 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 740 -3360 0 0 {name=l2058 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 740 -3300 0 0 {name=l2111 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 740 -3280 0 0 {name=l2112 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 800 -3190 3 0 {name=l4354 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 880 -3190 3 0 {name=l4358 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 900 -3190 3 0 {name=l2057 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1120 -3190 0 0 {name=l4359 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1200 -3180 3 0 {name=l4363 sig_type=std_logic lab=col_n[0]}
C {devices/lab_wire.sym} 1220 -3180 3 0 {name=l2060 sig_type=std_logic lab=col[0]}
C {devices/lab_wire.sym} 1450 -3190 0 0 {name=l4364 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1530 -3180 3 0 {name=l4367 sig_type=std_logic lab=col_n[1]}
C {devices/lab_wire.sym} 1480 -3180 3 0 {name=l1 sig_type=std_logic lab=en_C0_n}
C {devices/lab_wire.sym} 1550 -3180 3 0 {name=l2061 sig_type=std_logic lab=col[1]}
C {devices/lab_wire.sym} 800 -3510 3 0 {name=l2 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -3810 3 0 {name=l3 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1120 -3810 3 0 {name=l4 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1120 -3510 3 0 {name=l5 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1450 -3510 3 0 {name=l6 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1450 -3810 3 0 {name=l7 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1800 -3810 3 0 {name=l8 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1800 -3510 3 0 {name=l9 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2150 -3510 3 0 {name=l10 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2150 -3810 3 0 {name=l11 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2500 -3810 3 0 {name=l12 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2840 -3810 3 0 {name=l13 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2840 -3510 3 0 {name=l14 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2500 -3510 3 0 {name=l15 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3190 -3810 3 0 {name=l16 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3190 -3510 3 0 {name=l17 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3550 -3810 3 0 {name=l18 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3880 -3810 3 0 {name=l19 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3550 -3510 3 0 {name=l20 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3880 -3510 3 0 {name=l21 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4210 -3510 3 0 {name=l22 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4210 -3810 3 0 {name=l23 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4560 -3810 3 0 {name=l24 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4910 -3810 3 0 {name=l25 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4560 -3510 3 0 {name=l26 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4910 -3510 3 0 {name=l27 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5250 -3810 3 0 {name=l28 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5250 -3510 3 0 {name=l29 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5590 -3810 3 0 {name=l30 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5590 -3510 3 0 {name=l31 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2150 -3190 0 0 {name=l4374 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2230 -3180 3 0 {name=l4377 sig_type=std_logic lab=col_n[3]}
C {devices/lab_wire.sym} 2250 -3180 3 0 {name=l2063 sig_type=std_logic lab=col[3]}
C {devices/lab_wire.sym} 1800 -3190 0 0 {name=l4368 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1880 -3180 3 0 {name=l4371 sig_type=std_logic lab=col_n[2]}
C {devices/lab_wire.sym} 1900 -3180 3 0 {name=l2062 sig_type=std_logic lab=col[2]}
C {devices/lab_wire.sym} 2500 -3190 0 0 {name=l4378 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2580 -3180 3 0 {name=l4381 sig_type=std_logic lab=col_n[4]}
C {devices/lab_wire.sym} 2600 -3180 3 0 {name=l2064 sig_type=std_logic lab=col[4]}
C {devices/lab_wire.sym} 2840 -3190 0 0 {name=l4384 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2920 -3180 3 0 {name=l4387 sig_type=std_logic lab=col_n[5]}
C {devices/lab_wire.sym} 2940 -3180 3 0 {name=l2065 sig_type=std_logic lab=col[5]}
C {devices/lab_wire.sym} 3190 -3190 0 0 {name=l4434 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3270 -3180 3 0 {name=l4437 sig_type=std_logic lab=col_n[6]}
C {devices/lab_wire.sym} 2870 -3180 3 0 {name=l4797 sig_type=std_logic lab=en_bit_n[1]}
C {devices/lab_wire.sym} 3290 -3180 3 0 {name=l2075 sig_type=std_logic lab=col[6]}
C {devices/lab_wire.sym} 3550 -3190 0 0 {name=l50 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3630 -3180 3 0 {name=l51 sig_type=std_logic lab=col_n[7]}
C {devices/lab_wire.sym} 3220 -3180 3 0 {name=l52 sig_type=std_logic lab=en_bit_n[2]}
C {devices/lab_wire.sym} 3650 -3180 3 0 {name=l53 sig_type=std_logic lab=col[7]}
C {devices/lab_wire.sym} 3880 -3190 0 0 {name=l54 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3960 -3180 3 0 {name=l55 sig_type=std_logic lab=col_n[8]}
C {devices/lab_wire.sym} 3580 -3180 3 0 {name=l56 sig_type=std_logic lab=en_bit_n[0]}
C {devices/lab_wire.sym} 3980 -3180 3 0 {name=l57 sig_type=std_logic lab=col[8]}
C {devices/lab_wire.sym} 4290 -3180 3 0 {name=l58 sig_type=std_logic lab=col_n[9]}
C {devices/lab_wire.sym} 4310 -3180 3 0 {name=l59 sig_type=std_logic lab=col[9]}
C {devices/lab_wire.sym} 4210 -3190 0 0 {name=l60 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4640 -3180 3 0 {name=l61 sig_type=std_logic lab=col_n[10]}
C {devices/lab_wire.sym} 4660 -3180 3 0 {name=l62 sig_type=std_logic lab=col[10]}
C {devices/lab_wire.sym} 4560 -3190 0 0 {name=l63 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4990 -3180 3 0 {name=l64 sig_type=std_logic lab=col_n[11]}
C {devices/lab_wire.sym} 5010 -3180 3 0 {name=l65 sig_type=std_logic lab=col[11]}
C {devices/lab_wire.sym} 4910 -3190 0 0 {name=l66 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5330 -3180 3 0 {name=l67 sig_type=std_logic lab=col_n[12]}
C {devices/lab_wire.sym} 5350 -3180 3 0 {name=l68 sig_type=std_logic lab=col[12]}
C {devices/lab_wire.sym} 5250 -3190 0 0 {name=l69 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5590 -3190 0 0 {name=l4514 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5310 -3180 3 0 {name=l2052 sig_type=std_logic lab=sw}
C {devices/lab_wire.sym} 5370 -3180 3 0 {name=l2053 sig_type=std_logic lab=analog_in}
C {devices/lab_wire.sym} 5390 -3180 3 0 {name=l2054 sig_type=std_logic lab=sw_n}
C {devices/lab_wire.sym} 5670 -3180 3 0 {name=l4522 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5690 -3180 3 0 {name=l2092 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 800 -3430 2 1 {name=l4509 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 820 -3440 1 1 {name=l70 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 860 -3440 3 0 {name=l71 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -3430 2 1 {name=l72 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -3440 1 1 {name=l73 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1180 -3440 3 0 {name=l74 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1450 -3430 2 1 {name=l75 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1470 -3440 1 1 {name=l76 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1510 -3440 3 0 {name=l77 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1800 -3430 2 1 {name=l78 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1820 -3440 1 1 {name=l79 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1860 -3440 3 0 {name=l80 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2150 -3430 2 1 {name=l81 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2170 -3440 1 1 {name=l82 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2210 -3440 3 0 {name=l83 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2500 -3430 2 1 {name=l84 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2520 -3440 1 1 {name=l85 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2560 -3440 3 0 {name=l86 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2840 -3430 2 1 {name=l87 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2860 -3440 1 1 {name=l88 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2900 -3440 3 0 {name=l89 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3190 -3430 2 1 {name=l90 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3210 -3440 1 1 {name=l91 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3250 -3440 3 0 {name=l92 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3550 -3430 2 1 {name=l93 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3570 -3440 1 1 {name=l94 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3610 -3440 3 0 {name=l95 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3880 -3430 2 1 {name=l96 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3900 -3440 1 1 {name=l97 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3940 -3440 3 0 {name=l98 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4210 -3430 2 1 {name=l99 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4230 -3440 1 1 {name=l100 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4270 -3440 3 0 {name=l101 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4560 -3430 2 1 {name=l102 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4580 -3440 1 1 {name=l103 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4620 -3440 3 0 {name=l104 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4910 -3430 2 1 {name=l105 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4930 -3440 1 1 {name=l106 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4970 -3440 3 0 {name=l107 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5250 -3430 2 1 {name=l108 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5270 -3440 1 1 {name=l109 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5310 -3440 3 0 {name=l110 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5590 -3430 2 1 {name=l111 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5610 -3440 1 1 {name=l112 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5650 -3440 3 0 {name=l113 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5590 -3750 2 1 {name=l120 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5610 -3760 1 1 {name=l121 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5650 -3760 3 0 {name=l122 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5590 -4050 2 1 {name=l123 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5610 -4060 1 1 {name=l124 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5650 -4060 3 0 {name=l125 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4910 -4050 2 1 {name=l141 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4930 -4060 1 1 {name=l142 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4970 -4060 3 0 {name=l143 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5250 -4050 2 1 {name=l144 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5270 -4060 1 1 {name=l145 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5310 -4060 3 0 {name=l146 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5250 -3750 2 1 {name=l147 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5270 -3760 1 1 {name=l148 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5310 -3760 3 0 {name=l149 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4910 -3750 2 1 {name=l150 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4930 -3760 1 1 {name=l151 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4970 -3760 3 0 {name=l152 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4560 -3750 2 1 {name=l153 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4580 -3760 1 1 {name=l154 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4620 -3760 3 0 {name=l155 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4560 -4050 2 1 {name=l156 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4580 -4060 1 1 {name=l157 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4620 -4060 3 0 {name=l158 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4210 -4050 2 1 {name=l165 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4230 -4060 1 1 {name=l166 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4270 -4060 3 0 {name=l167 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4210 -3750 2 1 {name=l168 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4230 -3760 1 1 {name=l169 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4270 -3760 3 0 {name=l170 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3880 -3750 2 1 {name=l171 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3900 -3760 1 1 {name=l172 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3940 -3760 3 0 {name=l173 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3880 -4050 2 1 {name=l174 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3900 -4060 1 1 {name=l175 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3940 -4060 3 0 {name=l176 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3550 -4050 2 1 {name=l177 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3570 -4060 1 1 {name=l178 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3610 -4060 3 0 {name=l179 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3550 -3750 2 1 {name=l180 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3570 -3760 1 1 {name=l181 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3610 -3760 3 0 {name=l182 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3190 -3750 2 1 {name=l183 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3210 -3760 1 1 {name=l184 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3250 -3760 3 0 {name=l185 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3190 -4050 2 1 {name=l186 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3210 -4060 1 1 {name=l187 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3250 -4060 3 0 {name=l188 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2840 -4050 2 1 {name=l189 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2860 -4060 1 1 {name=l190 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2900 -4060 3 0 {name=l191 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2840 -3750 2 1 {name=l192 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2860 -3760 1 1 {name=l193 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2900 -3760 3 0 {name=l194 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2500 -3750 2 1 {name=l195 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2520 -3760 1 1 {name=l196 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2560 -3760 3 0 {name=l197 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2500 -4050 2 1 {name=l198 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2520 -4060 1 1 {name=l199 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2560 -4060 3 0 {name=l200 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2150 -4050 2 1 {name=l201 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2170 -4060 1 1 {name=l202 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2210 -4060 3 0 {name=l203 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2150 -3750 2 1 {name=l204 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2170 -3760 1 1 {name=l205 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2210 -3760 3 0 {name=l206 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1800 -3750 2 1 {name=l207 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1820 -3760 1 1 {name=l208 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1860 -3760 3 0 {name=l209 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1800 -4050 2 1 {name=l210 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1820 -4060 1 1 {name=l211 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1860 -4060 3 0 {name=l212 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1450 -4050 2 1 {name=l213 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1470 -4060 1 1 {name=l214 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1510 -4060 3 0 {name=l215 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -4050 2 1 {name=l216 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -4060 1 1 {name=l217 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1180 -4060 3 0 {name=l218 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -3750 2 1 {name=l219 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -3760 1 1 {name=l220 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1180 -3760 3 0 {name=l221 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1450 -3750 2 1 {name=l222 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1470 -3760 1 1 {name=l223 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1510 -3760 3 0 {name=l224 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 800 -4050 2 1 {name=l225 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 820 -4060 1 1 {name=l226 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 860 -4060 3 0 {name=l227 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 800 -3750 2 1 {name=l228 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 820 -3760 1 1 {name=l229 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 860 -3760 3 0 {name=l230 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 740 -3600 0 0 {name=l4102 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 740 -3660 0 0 {name=l4105 sig_type=std_logic lab=row_n[0]}
C {devices/lab_wire.sym} 740 -3640 0 0 {name=l4104 sig_type=std_logic lab=rowon_n[0]}
C {devices/lab_wire.sym} 740 -3620 0 0 {name=l4103 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 740 -3680 0 0 {name=l2093 sig_type=std_logic lab=rowoff_n[0]}
C {devices/lab_wire.sym} 740 -3900 0 0 {name=l4110 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 740 -3960 0 0 {name=l4111 sig_type=std_logic lab=row_n[1]}
C {devices/lab_wire.sym} 740 -3940 0 0 {name=l4112 sig_type=std_logic lab=rowon_n[1]}
C {devices/lab_wire.sym} 740 -3920 0 0 {name=l4113 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 740 -4230 0 0 {name=l4118 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 740 -4290 0 0 {name=l4119 sig_type=std_logic lab=row_n[2]}
C {devices/lab_wire.sym} 740 -4270 0 0 {name=l4120 sig_type=std_logic lab=rowon_n[2]}
C {devices/lab_wire.sym} 740 -4250 0 0 {name=l4121 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 740 -3980 0 0 {name=l2094 sig_type=std_logic lab=rowoff_n[1]}
C {devices/lab_wire.sym} 740 -4310 0 0 {name=l2095 sig_type=std_logic lab=rowoff_n[2]}
C {adc_sar_wafflecap_drv.sym} 520 -4100 0 0 {name=x49}
C {adc_sar_wafflecap_8_8.sym} 940 -3980 0 0 {name=x50}
C {adc_sar_wafflecap_8_8.sym} 1270 -3980 0 0 {name=x51}
C {adc_sar_wafflecap_8_8.sym} 1620 -3980 0 0 {name=x52}
C {adc_sar_wafflecap_8_8.sym} 1970 -3980 0 0 {name=x53}
C {adc_sar_wafflecap_8_8.sym} 2320 -3980 0 0 {name=x54}
C {adc_sar_wafflecap_8_8.sym} 2660 -3980 0 0 {name=x55}
C {adc_sar_wafflecap_8_8.sym} 3010 -3980 0 0 {name=x56}
C {adc_sar_wafflecap_8_8.sym} 3370 -3980 0 0 {name=x57}
C {adc_sar_wafflecap_8_8.sym} 3700 -3980 0 0 {name=x58}
C {adc_sar_wafflecap_8_8.sym} 4030 -3980 0 0 {name=x59}
C {adc_sar_wafflecap_8_8.sym} 4380 -3980 0 0 {name=x60}
C {adc_sar_wafflecap_8_8.sym} 4730 -3980 0 0 {name=x61}
C {adc_sar_wafflecap_8_8.sym} 5070 -3980 0 0 {name=x62}
C {devices/lab_wire.sym} 800 -4140 3 0 {name=l34 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1120 -4140 3 0 {name=l35 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1450 -4140 3 0 {name=l36 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1800 -4140 3 0 {name=l37 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2150 -4140 3 0 {name=l38 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2500 -4140 3 0 {name=l39 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2840 -4140 3 0 {name=l40 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3190 -4140 3 0 {name=l41 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3550 -4140 3 0 {name=l42 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3880 -4140 3 0 {name=l43 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4210 -4140 3 0 {name=l44 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4560 -4140 3 0 {name=l45 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4910 -4140 3 0 {name=l46 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5250 -4140 3 0 {name=l47 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5590 -4140 3 0 {name=l48 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5590 -4380 2 1 {name=l129 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5610 -4390 1 1 {name=l130 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5650 -4390 3 0 {name=l131 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4910 -4380 2 1 {name=l135 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4930 -4390 1 1 {name=l136 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4970 -4390 3 0 {name=l137 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5250 -4380 2 1 {name=l138 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5270 -4390 1 1 {name=l139 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5310 -4390 3 0 {name=l140 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4560 -4380 2 1 {name=l159 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4580 -4390 1 1 {name=l160 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4620 -4390 3 0 {name=l161 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4210 -4380 2 1 {name=l162 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4230 -4390 1 1 {name=l163 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4270 -4390 3 0 {name=l164 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3880 -4380 2 1 {name=l231 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3900 -4390 1 1 {name=l232 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3940 -4390 3 0 {name=l233 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3550 -4380 2 1 {name=l234 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3570 -4390 1 1 {name=l235 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3610 -4390 3 0 {name=l236 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3190 -4380 2 1 {name=l237 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3210 -4390 1 1 {name=l238 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3250 -4390 3 0 {name=l239 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2840 -4380 2 1 {name=l240 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2860 -4390 1 1 {name=l241 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2900 -4390 3 0 {name=l242 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2500 -4380 2 1 {name=l243 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2520 -4390 1 1 {name=l244 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2560 -4390 3 0 {name=l245 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2150 -4380 2 1 {name=l246 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2170 -4390 1 1 {name=l247 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2210 -4390 3 0 {name=l248 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1800 -4380 2 1 {name=l249 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1820 -4390 1 1 {name=l250 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1860 -4390 3 0 {name=l251 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1450 -4380 2 1 {name=l252 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1470 -4390 1 1 {name=l253 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1510 -4390 3 0 {name=l254 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -4380 2 1 {name=l255 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -4390 1 1 {name=l256 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1180 -4390 3 0 {name=l257 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 800 -4380 2 1 {name=l258 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 820 -4390 1 1 {name=l259 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 860 -4390 3 0 {name=l260 sig_type=std_logic lab=ctop}
C {adc_sar_wafflecap_drv.sym} 520 -4420 0 0 {name=x65}
C {adc_sar_wafflecap_8_8.sym} 940 -4300 0 0 {name=x66}
C {adc_sar_wafflecap_8_8.sym} 1270 -4300 0 0 {name=x67}
C {adc_sar_wafflecap_8_8.sym} 1620 -4300 0 0 {name=x68}
C {adc_sar_wafflecap_8_8.sym} 1970 -4300 0 0 {name=x69}
C {adc_sar_wafflecap_8_8.sym} 2320 -4300 0 0 {name=x70}
C {adc_sar_wafflecap_8_8.sym} 2660 -4300 0 0 {name=x71}
C {adc_sar_wafflecap_8_8.sym} 3010 -4300 0 0 {name=x72}
C {adc_sar_wafflecap_8_8.sym} 3370 -4300 0 0 {name=x73}
C {adc_sar_wafflecap_8_8.sym} 3700 -4300 0 0 {name=x74}
C {adc_sar_wafflecap_8_8.sym} 4030 -4300 0 0 {name=x75}
C {adc_sar_wafflecap_8_8.sym} 4380 -4300 0 0 {name=x76}
C {adc_sar_wafflecap_8_8.sym} 4730 -4300 0 0 {name=x77}
C {adc_sar_wafflecap_8_8.sym} 5070 -4300 0 0 {name=x78}
C {devices/lab_wire.sym} 800 -4460 3 0 {name=l261 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1120 -4460 3 0 {name=l262 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1450 -4460 3 0 {name=l263 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1800 -4460 3 0 {name=l264 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2150 -4460 3 0 {name=l265 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2500 -4460 3 0 {name=l266 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2840 -4460 3 0 {name=l267 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3190 -4460 3 0 {name=l268 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3550 -4460 3 0 {name=l269 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3880 -4460 3 0 {name=l270 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4210 -4460 3 0 {name=l271 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4560 -4460 3 0 {name=l272 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4910 -4460 3 0 {name=l273 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5250 -4460 3 0 {name=l274 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5590 -4460 3 0 {name=l275 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5590 -4700 2 1 {name=l277 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5610 -4710 1 1 {name=l278 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5650 -4710 3 0 {name=l279 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4910 -4700 2 1 {name=l283 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4930 -4710 1 1 {name=l284 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4970 -4710 3 0 {name=l285 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5250 -4700 2 1 {name=l286 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5270 -4710 1 1 {name=l287 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5310 -4710 3 0 {name=l288 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4560 -4700 2 1 {name=l289 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4580 -4710 1 1 {name=l290 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4620 -4710 3 0 {name=l291 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4210 -4700 2 1 {name=l292 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4230 -4710 1 1 {name=l293 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4270 -4710 3 0 {name=l294 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3880 -4700 2 1 {name=l295 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3900 -4710 1 1 {name=l296 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3940 -4710 3 0 {name=l297 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3550 -4700 2 1 {name=l298 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3570 -4710 1 1 {name=l299 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3610 -4710 3 0 {name=l300 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3190 -4700 2 1 {name=l301 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3210 -4710 1 1 {name=l302 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3250 -4710 3 0 {name=l303 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2840 -4700 2 1 {name=l304 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2860 -4710 1 1 {name=l305 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2900 -4710 3 0 {name=l306 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2500 -4700 2 1 {name=l307 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2520 -4710 1 1 {name=l308 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2560 -4710 3 0 {name=l309 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2150 -4700 2 1 {name=l310 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2170 -4710 1 1 {name=l311 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2210 -4710 3 0 {name=l312 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1800 -4700 2 1 {name=l313 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1820 -4710 1 1 {name=l314 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1860 -4710 3 0 {name=l315 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1450 -4700 2 1 {name=l316 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1470 -4710 1 1 {name=l317 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1510 -4710 3 0 {name=l318 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -4700 2 1 {name=l319 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -4710 1 1 {name=l320 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1180 -4710 3 0 {name=l321 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 800 -4700 2 1 {name=l322 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 820 -4710 1 1 {name=l323 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 860 -4710 3 0 {name=l324 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 740 -4550 0 0 {name=l325 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 740 -4610 0 0 {name=l326 sig_type=std_logic lab=row_n[3]}
C {devices/lab_wire.sym} 740 -4590 0 0 {name=l327 sig_type=std_logic lab=rowon_n[3]}
C {devices/lab_wire.sym} 740 -4570 0 0 {name=l328 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 740 -4880 0 0 {name=l329 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 740 -4940 0 0 {name=l330 sig_type=std_logic lab=row_n[4]}
C {devices/lab_wire.sym} 740 -4920 0 0 {name=l331 sig_type=std_logic lab=rowon_n[4]}
C {devices/lab_wire.sym} 740 -4900 0 0 {name=l332 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 740 -4630 0 0 {name=l333 sig_type=std_logic lab=rowoff_n[3]}
C {devices/lab_wire.sym} 740 -4960 0 0 {name=l334 sig_type=std_logic lab=rowoff_n[4]}
C {adc_sar_wafflecap_drv.sym} 520 -4750 0 0 {name=x81}
C {adc_sar_wafflecap_8_8.sym} 940 -4630 0 0 {name=x82}
C {adc_sar_wafflecap_8_8.sym} 1270 -4630 0 0 {name=x83}
C {adc_sar_wafflecap_8_8.sym} 1620 -4630 0 0 {name=x84}
C {adc_sar_wafflecap_8_8.sym} 1970 -4630 0 0 {name=x85}
C {adc_sar_wafflecap_8_8.sym} 2320 -4630 0 0 {name=x86}
C {adc_sar_wafflecap_8_8.sym} 2660 -4630 0 0 {name=x87}
C {adc_sar_wafflecap_8_8.sym} 3010 -4630 0 0 {name=x88}
C {adc_sar_wafflecap_8_8.sym} 3370 -4630 0 0 {name=x89}
C {adc_sar_wafflecap_8_8.sym} 3700 -4630 0 0 {name=x90}
C {adc_sar_wafflecap_8_8.sym} 4030 -4630 0 0 {name=x91}
C {adc_sar_wafflecap_8_8.sym} 4380 -4630 0 0 {name=x92}
C {adc_sar_wafflecap_8_8.sym} 4730 -4630 0 0 {name=x93}
C {adc_sar_wafflecap_8_8.sym} 5070 -4630 0 0 {name=x94}
C {devices/lab_wire.sym} 800 -4790 3 0 {name=l335 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1120 -4790 3 0 {name=l336 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1450 -4790 3 0 {name=l337 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1800 -4790 3 0 {name=l338 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2150 -4790 3 0 {name=l339 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2500 -4790 3 0 {name=l340 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2840 -4790 3 0 {name=l341 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3190 -4790 3 0 {name=l342 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3550 -4790 3 0 {name=l343 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3880 -4790 3 0 {name=l344 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4210 -4790 3 0 {name=l345 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4560 -4790 3 0 {name=l346 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4910 -4790 3 0 {name=l347 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5250 -4790 3 0 {name=l348 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5590 -4790 3 0 {name=l349 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5590 -5030 2 1 {name=l351 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5610 -5040 1 1 {name=l352 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5650 -5040 3 0 {name=l353 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4910 -5030 2 1 {name=l357 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4930 -5040 1 1 {name=l358 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4970 -5040 3 0 {name=l359 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5250 -5030 2 1 {name=l360 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5270 -5040 1 1 {name=l361 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5310 -5040 3 0 {name=l362 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4560 -5030 2 1 {name=l363 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4580 -5040 1 1 {name=l364 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4620 -5040 3 0 {name=l365 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4210 -5030 2 1 {name=l366 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4230 -5040 1 1 {name=l367 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4270 -5040 3 0 {name=l368 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3880 -5030 2 1 {name=l369 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3900 -5040 1 1 {name=l370 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3940 -5040 3 0 {name=l371 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3550 -5030 2 1 {name=l372 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3570 -5040 1 1 {name=l373 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3610 -5040 3 0 {name=l374 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3190 -5030 2 1 {name=l375 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3210 -5040 1 1 {name=l376 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3250 -5040 3 0 {name=l377 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2840 -5030 2 1 {name=l378 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2860 -5040 1 1 {name=l379 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2900 -5040 3 0 {name=l380 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2500 -5030 2 1 {name=l381 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2520 -5040 1 1 {name=l382 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2560 -5040 3 0 {name=l383 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2150 -5030 2 1 {name=l384 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2170 -5040 1 1 {name=l385 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2210 -5040 3 0 {name=l386 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1800 -5030 2 1 {name=l387 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1820 -5040 1 1 {name=l388 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1860 -5040 3 0 {name=l389 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1450 -5030 2 1 {name=l390 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1470 -5040 1 1 {name=l391 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1510 -5040 3 0 {name=l392 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -5030 2 1 {name=l393 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -5040 1 1 {name=l394 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1180 -5040 3 0 {name=l395 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 800 -5030 2 1 {name=l396 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 820 -5040 1 1 {name=l397 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 860 -5040 3 0 {name=l398 sig_type=std_logic lab=ctop}
C {adc_sar_wafflecap_drv.sym} 520 -5100 0 0 {name=x97}
C {adc_sar_wafflecap_8_8.sym} 940 -4980 0 0 {name=x98}
C {adc_sar_wafflecap_8_8.sym} 1270 -4980 0 0 {name=x99}
C {adc_sar_wafflecap_8_8.sym} 1620 -4980 0 0 {name=x100}
C {adc_sar_wafflecap_8_8.sym} 1970 -4980 0 0 {name=x101}
C {adc_sar_wafflecap_8_8.sym} 2320 -4980 0 0 {name=x102}
C {adc_sar_wafflecap_8_8.sym} 2660 -4980 0 0 {name=x103}
C {adc_sar_wafflecap_8_8.sym} 3010 -4980 0 0 {name=x104}
C {adc_sar_wafflecap_8_8.sym} 3370 -4980 0 0 {name=x105}
C {adc_sar_wafflecap_8_8.sym} 3700 -4980 0 0 {name=x106}
C {adc_sar_wafflecap_8_8.sym} 4030 -4980 0 0 {name=x107}
C {adc_sar_wafflecap_8_8.sym} 4380 -4980 0 0 {name=x108}
C {adc_sar_wafflecap_8_8.sym} 4730 -4980 0 0 {name=x109}
C {adc_sar_wafflecap_8_8.sym} 5070 -4980 0 0 {name=x110}
C {devices/lab_wire.sym} 800 -5140 3 0 {name=l399 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1120 -5140 3 0 {name=l400 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1450 -5140 3 0 {name=l401 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1800 -5140 3 0 {name=l402 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2150 -5140 3 0 {name=l403 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2500 -5140 3 0 {name=l404 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2840 -5140 3 0 {name=l405 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3190 -5140 3 0 {name=l406 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3550 -5140 3 0 {name=l407 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3880 -5140 3 0 {name=l408 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4210 -5140 3 0 {name=l409 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4560 -5140 3 0 {name=l410 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4910 -5140 3 0 {name=l411 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5250 -5140 3 0 {name=l412 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5590 -5140 3 0 {name=l413 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5590 -5380 2 1 {name=l415 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5610 -5390 1 1 {name=l416 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5650 -5390 3 0 {name=l417 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4910 -5380 2 1 {name=l421 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4930 -5390 1 1 {name=l422 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4970 -5390 3 0 {name=l423 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5250 -5380 2 1 {name=l424 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5270 -5390 1 1 {name=l425 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5310 -5390 3 0 {name=l426 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4560 -5380 2 1 {name=l427 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4580 -5390 1 1 {name=l428 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4620 -5390 3 0 {name=l429 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4210 -5380 2 1 {name=l430 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4230 -5390 1 1 {name=l431 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4270 -5390 3 0 {name=l432 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3880 -5380 2 1 {name=l433 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3900 -5390 1 1 {name=l434 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3940 -5390 3 0 {name=l435 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3550 -5380 2 1 {name=l436 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3570 -5390 1 1 {name=l437 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3610 -5390 3 0 {name=l438 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3190 -5380 2 1 {name=l439 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3210 -5390 1 1 {name=l440 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3250 -5390 3 0 {name=l441 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2840 -5380 2 1 {name=l442 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2860 -5390 1 1 {name=l443 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2900 -5390 3 0 {name=l444 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2500 -5380 2 1 {name=l445 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2520 -5390 1 1 {name=l446 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2560 -5390 3 0 {name=l447 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2150 -5380 2 1 {name=l448 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2170 -5390 1 1 {name=l449 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2210 -5390 3 0 {name=l450 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1800 -5380 2 1 {name=l451 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1820 -5390 1 1 {name=l452 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1860 -5390 3 0 {name=l453 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1450 -5380 2 1 {name=l454 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1470 -5390 1 1 {name=l455 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1510 -5390 3 0 {name=l456 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -5380 2 1 {name=l457 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -5390 1 1 {name=l458 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1180 -5390 3 0 {name=l459 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 800 -5380 2 1 {name=l460 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 820 -5390 1 1 {name=l461 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 860 -5390 3 0 {name=l462 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 740 -5230 0 0 {name=l463 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 740 -5290 0 0 {name=l464 sig_type=std_logic lab=row_n[5]}
C {devices/lab_wire.sym} 740 -5270 0 0 {name=l465 sig_type=std_logic lab=rowon_n[5]}
C {devices/lab_wire.sym} 740 -5250 0 0 {name=l466 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 740 -5560 0 0 {name=l467 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 740 -5620 0 0 {name=l468 sig_type=std_logic lab=row_n[6]}
C {devices/lab_wire.sym} 740 -5600 0 0 {name=l469 sig_type=std_logic lab=rowon_n[6]}
C {devices/lab_wire.sym} 740 -5580 0 0 {name=l470 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 740 -5310 0 0 {name=l471 sig_type=std_logic lab=rowoff_n[5]}
C {devices/lab_wire.sym} 740 -5640 0 0 {name=l472 sig_type=std_logic lab=rowoff_n[6]}
C {adc_sar_wafflecap_drv.sym} 520 -5430 0 0 {name=x113}
C {adc_sar_wafflecap_8_8.sym} 940 -5310 0 0 {name=x114}
C {adc_sar_wafflecap_8_8.sym} 1270 -5310 0 0 {name=x115}
C {adc_sar_wafflecap_8_8.sym} 1620 -5310 0 0 {name=x116}
C {adc_sar_wafflecap_8_8.sym} 1970 -5310 0 0 {name=x117}
C {adc_sar_wafflecap_8_8.sym} 2320 -5310 0 0 {name=x118}
C {adc_sar_wafflecap_8_8.sym} 2660 -5310 0 0 {name=x119}
C {adc_sar_wafflecap_8_8.sym} 3010 -5310 0 0 {name=x120}
C {adc_sar_wafflecap_8_8.sym} 3370 -5310 0 0 {name=x121}
C {adc_sar_wafflecap_8_8.sym} 3700 -5310 0 0 {name=x122}
C {adc_sar_wafflecap_8_8.sym} 4030 -5310 0 0 {name=x123}
C {adc_sar_wafflecap_8_8.sym} 4380 -5310 0 0 {name=x124}
C {adc_sar_wafflecap_8_8.sym} 4730 -5310 0 0 {name=x125}
C {adc_sar_wafflecap_8_8.sym} 5070 -5310 0 0 {name=x126}
C {devices/lab_wire.sym} 800 -5470 3 0 {name=l473 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1120 -5470 3 0 {name=l474 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1450 -5470 3 0 {name=l475 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1800 -5470 3 0 {name=l476 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2150 -5470 3 0 {name=l477 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2500 -5470 3 0 {name=l478 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2840 -5470 3 0 {name=l479 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3190 -5470 3 0 {name=l480 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3550 -5470 3 0 {name=l481 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3880 -5470 3 0 {name=l482 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4210 -5470 3 0 {name=l483 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4560 -5470 3 0 {name=l484 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4910 -5470 3 0 {name=l485 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5250 -5470 3 0 {name=l486 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5590 -5470 3 0 {name=l487 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5590 -5710 2 1 {name=l489 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5610 -5720 1 1 {name=l490 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5650 -5720 3 0 {name=l491 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4910 -5710 2 1 {name=l495 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4930 -5720 1 1 {name=l496 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4970 -5720 3 0 {name=l497 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5250 -5710 2 1 {name=l498 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5270 -5720 1 1 {name=l499 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5310 -5720 3 0 {name=l500 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4560 -5710 2 1 {name=l501 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4580 -5720 1 1 {name=l502 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4620 -5720 3 0 {name=l503 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4210 -5710 2 1 {name=l504 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4230 -5720 1 1 {name=l505 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4270 -5720 3 0 {name=l506 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3880 -5710 2 1 {name=l507 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3900 -5720 1 1 {name=l508 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3940 -5720 3 0 {name=l509 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3550 -5710 2 1 {name=l510 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3570 -5720 1 1 {name=l511 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3610 -5720 3 0 {name=l512 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3190 -5710 2 1 {name=l513 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3210 -5720 1 1 {name=l514 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3250 -5720 3 0 {name=l515 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2840 -5710 2 1 {name=l516 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2860 -5720 1 1 {name=l517 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2900 -5720 3 0 {name=l518 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2500 -5710 2 1 {name=l519 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2520 -5720 1 1 {name=l520 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2560 -5720 3 0 {name=l521 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2150 -5710 2 1 {name=l522 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2170 -5720 1 1 {name=l523 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2210 -5720 3 0 {name=l524 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1800 -5710 2 1 {name=l525 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1820 -5720 1 1 {name=l526 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1860 -5720 3 0 {name=l527 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1450 -5710 2 1 {name=l528 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1470 -5720 1 1 {name=l529 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1510 -5720 3 0 {name=l530 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -5710 2 1 {name=l531 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -5720 1 1 {name=l532 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1180 -5720 3 0 {name=l533 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 800 -5710 2 1 {name=l534 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 820 -5720 1 1 {name=l535 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 860 -5720 3 0 {name=l536 sig_type=std_logic lab=ctop}
C {adc_sar_wafflecap_drv.sym} 520 -5750 0 0 {name=x129}
C {adc_sar_wafflecap_8_8.sym} 940 -5630 0 0 {name=x130}
C {adc_sar_wafflecap_8_8.sym} 1270 -5630 0 0 {name=x131}
C {adc_sar_wafflecap_8_8.sym} 1620 -5630 0 0 {name=x132}
C {adc_sar_wafflecap_8_8.sym} 1970 -5630 0 0 {name=x133}
C {adc_sar_wafflecap_8_8.sym} 2320 -5630 0 0 {name=x134}
C {adc_sar_wafflecap_8_8.sym} 2660 -5630 0 0 {name=x135}
C {adc_sar_wafflecap_8_8.sym} 3010 -5630 0 0 {name=x136}
C {adc_sar_wafflecap_8_8.sym} 3370 -5630 0 0 {name=x137}
C {adc_sar_wafflecap_8_8.sym} 3700 -5630 0 0 {name=x138}
C {adc_sar_wafflecap_8_8.sym} 4030 -5630 0 0 {name=x139}
C {adc_sar_wafflecap_8_8.sym} 4380 -5630 0 0 {name=x140}
C {adc_sar_wafflecap_8_8.sym} 4730 -5630 0 0 {name=x141}
C {adc_sar_wafflecap_8_8.sym} 5070 -5630 0 0 {name=x142}
C {devices/lab_wire.sym} 800 -5790 3 0 {name=l537 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1120 -5790 3 0 {name=l538 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1450 -5790 3 0 {name=l539 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1800 -5790 3 0 {name=l540 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2150 -5790 3 0 {name=l541 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2500 -5790 3 0 {name=l542 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2840 -5790 3 0 {name=l543 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3190 -5790 3 0 {name=l544 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3550 -5790 3 0 {name=l545 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3880 -5790 3 0 {name=l546 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4210 -5790 3 0 {name=l547 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4560 -5790 3 0 {name=l548 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4910 -5790 3 0 {name=l549 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5250 -5790 3 0 {name=l550 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5590 -5790 3 0 {name=l551 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5590 -6030 2 1 {name=l553 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5610 -6040 1 1 {name=l554 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5650 -6040 3 0 {name=l555 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4910 -6030 2 1 {name=l559 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4930 -6040 1 1 {name=l560 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4970 -6040 3 0 {name=l561 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5250 -6030 2 1 {name=l562 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5270 -6040 1 1 {name=l563 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5310 -6040 3 0 {name=l564 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4560 -6030 2 1 {name=l565 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4580 -6040 1 1 {name=l566 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4620 -6040 3 0 {name=l567 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4210 -6030 2 1 {name=l568 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4230 -6040 1 1 {name=l569 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4270 -6040 3 0 {name=l570 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3880 -6030 2 1 {name=l571 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3900 -6040 1 1 {name=l572 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3940 -6040 3 0 {name=l573 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3550 -6030 2 1 {name=l574 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3570 -6040 1 1 {name=l575 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3610 -6040 3 0 {name=l576 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3190 -6030 2 1 {name=l577 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3210 -6040 1 1 {name=l578 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3250 -6040 3 0 {name=l579 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2840 -6030 2 1 {name=l580 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2860 -6040 1 1 {name=l581 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2900 -6040 3 0 {name=l582 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2500 -6030 2 1 {name=l583 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2520 -6040 1 1 {name=l584 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2560 -6040 3 0 {name=l585 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2150 -6030 2 1 {name=l586 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2170 -6040 1 1 {name=l587 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2210 -6040 3 0 {name=l588 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1800 -6030 2 1 {name=l589 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1820 -6040 1 1 {name=l590 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1860 -6040 3 0 {name=l591 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1450 -6030 2 1 {name=l592 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1470 -6040 1 1 {name=l593 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1510 -6040 3 0 {name=l594 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -6030 2 1 {name=l595 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -6040 1 1 {name=l596 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1180 -6040 3 0 {name=l597 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 800 -6030 2 1 {name=l598 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 820 -6040 1 1 {name=l599 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 860 -6040 3 0 {name=l600 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 740 -5880 0 0 {name=l601 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 740 -5940 0 0 {name=l602 sig_type=std_logic lab=row_n[7]}
C {devices/lab_wire.sym} 740 -5920 0 0 {name=l603 sig_type=std_logic lab=rowon_n[7]}
C {devices/lab_wire.sym} 740 -5900 0 0 {name=l604 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 740 -6210 0 0 {name=l605 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 740 -6270 0 0 {name=l606 sig_type=std_logic lab=row_n[8]}
C {devices/lab_wire.sym} 740 -6250 0 0 {name=l607 sig_type=std_logic lab=rowon_n[8]}
C {devices/lab_wire.sym} 740 -6230 0 0 {name=l608 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 740 -5960 0 0 {name=l609 sig_type=std_logic lab=rowoff_n[7]}
C {devices/lab_wire.sym} 740 -6290 0 0 {name=l610 sig_type=std_logic lab=rowoff_n[8]}
C {adc_sar_wafflecap_drv.sym} 520 -6080 0 0 {name=x145}
C {adc_sar_wafflecap_8_8.sym} 940 -5960 0 0 {name=x146}
C {adc_sar_wafflecap_8_8.sym} 1270 -5960 0 0 {name=x147}
C {adc_sar_wafflecap_8_8.sym} 1620 -5960 0 0 {name=x148}
C {adc_sar_wafflecap_8_8.sym} 1970 -5960 0 0 {name=x149}
C {adc_sar_wafflecap_8_8.sym} 2320 -5960 0 0 {name=x150}
C {adc_sar_wafflecap_8_8.sym} 2660 -5960 0 0 {name=x151}
C {adc_sar_wafflecap_8_8.sym} 3010 -5960 0 0 {name=x152}
C {adc_sar_wafflecap_8_8.sym} 3370 -5960 0 0 {name=x153}
C {adc_sar_wafflecap_8_8.sym} 3700 -5960 0 0 {name=x154}
C {adc_sar_wafflecap_8_8.sym} 4030 -5960 0 0 {name=x155}
C {adc_sar_wafflecap_8_8.sym} 4380 -5960 0 0 {name=x156}
C {adc_sar_wafflecap_8_8.sym} 4730 -5960 0 0 {name=x157}
C {adc_sar_wafflecap_8_8.sym} 5070 -5960 0 0 {name=x158}
C {devices/lab_wire.sym} 800 -6120 3 0 {name=l611 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1120 -6120 3 0 {name=l612 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1450 -6120 3 0 {name=l613 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1800 -6120 3 0 {name=l614 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2150 -6120 3 0 {name=l615 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2500 -6120 3 0 {name=l616 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2840 -6120 3 0 {name=l617 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3190 -6120 3 0 {name=l618 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3550 -6120 3 0 {name=l619 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3880 -6120 3 0 {name=l620 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4210 -6120 3 0 {name=l621 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4560 -6120 3 0 {name=l622 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4910 -6120 3 0 {name=l623 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5250 -6120 3 0 {name=l624 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5590 -6120 3 0 {name=l625 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5590 -6360 2 1 {name=l627 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5610 -6370 1 1 {name=l628 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5650 -6370 3 0 {name=l629 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4910 -6360 2 1 {name=l633 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4930 -6370 1 1 {name=l634 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4970 -6370 3 0 {name=l635 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5250 -6360 2 1 {name=l636 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5270 -6370 1 1 {name=l637 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5310 -6370 3 0 {name=l638 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4560 -6360 2 1 {name=l639 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4580 -6370 1 1 {name=l640 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4620 -6370 3 0 {name=l641 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4210 -6360 2 1 {name=l642 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4230 -6370 1 1 {name=l643 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4270 -6370 3 0 {name=l644 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3880 -6360 2 1 {name=l645 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3900 -6370 1 1 {name=l646 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3940 -6370 3 0 {name=l647 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3550 -6360 2 1 {name=l648 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3570 -6370 1 1 {name=l649 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3610 -6370 3 0 {name=l650 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3190 -6360 2 1 {name=l651 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3210 -6370 1 1 {name=l652 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3250 -6370 3 0 {name=l653 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2840 -6360 2 1 {name=l654 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2860 -6370 1 1 {name=l655 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2900 -6370 3 0 {name=l656 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2500 -6360 2 1 {name=l657 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2520 -6370 1 1 {name=l658 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2560 -6370 3 0 {name=l659 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2150 -6360 2 1 {name=l660 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2170 -6370 1 1 {name=l661 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2210 -6370 3 0 {name=l662 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1800 -6360 2 1 {name=l663 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1820 -6370 1 1 {name=l664 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1860 -6370 3 0 {name=l665 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1450 -6360 2 1 {name=l666 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1470 -6370 1 1 {name=l667 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1510 -6370 3 0 {name=l668 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -6360 2 1 {name=l669 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -6370 1 1 {name=l670 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1180 -6370 3 0 {name=l671 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 800 -6360 2 1 {name=l672 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 820 -6370 1 1 {name=l673 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 860 -6370 3 0 {name=l674 sig_type=std_logic lab=ctop}
C {adc_sar_wafflecap_drv.sym} 520 -6390 0 0 {name=x161}
C {adc_sar_wafflecap_8_8.sym} 940 -6270 0 0 {name=x162}
C {adc_sar_wafflecap_8_8.sym} 1270 -6270 0 0 {name=x163}
C {adc_sar_wafflecap_8_8.sym} 1620 -6270 0 0 {name=x164}
C {adc_sar_wafflecap_8_8.sym} 1970 -6270 0 0 {name=x165}
C {adc_sar_wafflecap_8_8.sym} 2320 -6270 0 0 {name=x166}
C {adc_sar_wafflecap_8_8.sym} 2660 -6270 0 0 {name=x167}
C {adc_sar_wafflecap_8_8.sym} 3010 -6270 0 0 {name=x168}
C {adc_sar_wafflecap_8_8.sym} 3370 -6270 0 0 {name=x169}
C {adc_sar_wafflecap_8_8.sym} 3700 -6270 0 0 {name=x170}
C {adc_sar_wafflecap_8_8.sym} 4030 -6270 0 0 {name=x171}
C {adc_sar_wafflecap_8_8.sym} 4380 -6270 0 0 {name=x172}
C {adc_sar_wafflecap_8_8.sym} 4730 -6270 0 0 {name=x173}
C {adc_sar_wafflecap_8_8.sym} 5070 -6270 0 0 {name=x174}
C {devices/lab_wire.sym} 800 -6430 3 0 {name=l675 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1120 -6430 3 0 {name=l676 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1450 -6430 3 0 {name=l677 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1800 -6430 3 0 {name=l678 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2150 -6430 3 0 {name=l679 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2500 -6430 3 0 {name=l680 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2840 -6430 3 0 {name=l681 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3190 -6430 3 0 {name=l682 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3550 -6430 3 0 {name=l683 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3880 -6430 3 0 {name=l684 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4210 -6430 3 0 {name=l685 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4560 -6430 3 0 {name=l686 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4910 -6430 3 0 {name=l687 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5250 -6430 3 0 {name=l688 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5590 -6430 3 0 {name=l689 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5590 -6670 2 1 {name=l691 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5610 -6680 1 1 {name=l692 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5650 -6680 3 0 {name=l693 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4910 -6670 2 1 {name=l697 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4930 -6680 1 1 {name=l698 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4970 -6680 3 0 {name=l699 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5250 -6670 2 1 {name=l700 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5270 -6680 1 1 {name=l701 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5310 -6680 3 0 {name=l702 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4560 -6670 2 1 {name=l703 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4580 -6680 1 1 {name=l704 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4620 -6680 3 0 {name=l705 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4210 -6670 2 1 {name=l706 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4230 -6680 1 1 {name=l707 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4270 -6680 3 0 {name=l708 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3880 -6670 2 1 {name=l709 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3900 -6680 1 1 {name=l710 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3940 -6680 3 0 {name=l711 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3550 -6670 2 1 {name=l712 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3570 -6680 1 1 {name=l713 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3610 -6680 3 0 {name=l714 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3190 -6670 2 1 {name=l715 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3210 -6680 1 1 {name=l716 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3250 -6680 3 0 {name=l717 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2840 -6670 2 1 {name=l718 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2860 -6680 1 1 {name=l719 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2900 -6680 3 0 {name=l720 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2500 -6670 2 1 {name=l721 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2520 -6680 1 1 {name=l722 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2560 -6680 3 0 {name=l723 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2150 -6670 2 1 {name=l724 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2170 -6680 1 1 {name=l725 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2210 -6680 3 0 {name=l726 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1800 -6670 2 1 {name=l727 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1820 -6680 1 1 {name=l728 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1860 -6680 3 0 {name=l729 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1450 -6670 2 1 {name=l730 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1470 -6680 1 1 {name=l731 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1510 -6680 3 0 {name=l732 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -6670 2 1 {name=l733 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -6680 1 1 {name=l734 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1180 -6680 3 0 {name=l735 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 800 -6670 2 1 {name=l736 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 820 -6680 1 1 {name=l737 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 860 -6680 3 0 {name=l738 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 740 -6520 0 0 {name=l739 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 740 -6580 0 0 {name=l740 sig_type=std_logic lab=row_n[9]}
C {devices/lab_wire.sym} 740 -6560 0 0 {name=l741 sig_type=std_logic lab=rowon_n[9]}
C {devices/lab_wire.sym} 740 -6540 0 0 {name=l742 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 740 -6850 0 0 {name=l743 sig_type=std_logic lab=sample_n}
C {devices/lab_wire.sym} 740 -6910 0 0 {name=l744 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 740 -6890 0 0 {name=l745 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 740 -6870 0 0 {name=l746 sig_type=std_logic lab=sample}
C {devices/lab_wire.sym} 740 -6600 0 0 {name=l747 sig_type=std_logic lab=rowoff_n[9]}
C {devices/lab_wire.sym} 740 -6930 0 0 {name=l748 sig_type=std_logic lab=VSS}
C {adc_sar_wafflecap_drv.sym} 520 -6720 0 0 {name=x177}
C {devices/lab_wire.sym} 800 -6760 3 0 {name=l749 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1120 -6760 3 0 {name=l750 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1450 -6760 3 0 {name=l751 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 1800 -6760 3 0 {name=l752 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2150 -6760 3 0 {name=l753 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2500 -6760 3 0 {name=l754 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 2840 -6760 3 0 {name=l755 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3190 -6760 3 0 {name=l756 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3550 -6760 3 0 {name=l757 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 3880 -6760 3 0 {name=l758 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4210 -6760 3 0 {name=l759 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4560 -6760 3 0 {name=l760 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 4910 -6760 3 0 {name=l761 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5250 -6760 3 0 {name=l762 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5590 -6760 3 0 {name=l763 sig_type=std_logic lab=VSS}
C {devices/lab_wire.sym} 5590 -7000 2 1 {name=l765 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5610 -7010 1 1 {name=l766 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5650 -7010 3 0 {name=l767 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4910 -7000 2 1 {name=l771 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4930 -7010 1 1 {name=l772 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4970 -7010 3 0 {name=l773 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 5250 -7000 2 1 {name=l774 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 5270 -7010 1 1 {name=l775 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 5310 -7010 3 0 {name=l776 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4560 -7000 2 1 {name=l777 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4580 -7010 1 1 {name=l778 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4620 -7010 3 0 {name=l779 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 4210 -7000 2 1 {name=l780 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 4230 -7010 1 1 {name=l781 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 4270 -7010 3 0 {name=l782 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3880 -7000 2 1 {name=l783 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3900 -7010 1 1 {name=l784 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3940 -7010 3 0 {name=l785 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3550 -7000 2 1 {name=l786 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3570 -7010 1 1 {name=l787 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3610 -7010 3 0 {name=l788 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 3190 -7000 2 1 {name=l789 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 3210 -7010 1 1 {name=l790 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 3250 -7010 3 0 {name=l791 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2840 -7000 2 1 {name=l792 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2860 -7010 1 1 {name=l793 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2900 -7010 3 0 {name=l794 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2500 -7000 2 1 {name=l795 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2520 -7010 1 1 {name=l796 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2560 -7010 3 0 {name=l797 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 2150 -7000 2 1 {name=l798 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 2170 -7010 1 1 {name=l799 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 2210 -7010 3 0 {name=l800 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1800 -7000 2 1 {name=l801 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1820 -7010 1 1 {name=l802 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1860 -7010 3 0 {name=l803 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1450 -7000 2 1 {name=l804 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1470 -7010 1 1 {name=l805 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1510 -7010 3 0 {name=l806 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 1120 -7000 2 1 {name=l807 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 1140 -7010 1 1 {name=l808 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 1180 -7010 3 0 {name=l809 sig_type=std_logic lab=ctop}
C {devices/lab_wire.sym} 800 -7000 2 1 {name=l810 sig_type=std_logic lab=VDD}
C {devices/lab_wire.sym} 820 -7010 1 1 {name=l811 sig_type=std_logic lab=vcm}
C {devices/lab_wire.sym} 860 -7010 3 0 {name=l812 sig_type=std_logic lab=ctop}
C {adc_sar_wafflecap_dummy.sym} 5010 -6680 0 0 {name=x180}
C {adc_sar_wafflecap_dummy.sym} 4670 -6680 0 0 {name=x181}
C {adc_sar_wafflecap_dummy.sym} 4320 -6680 0 0 {name=x182}
C {adc_sar_wafflecap_dummy.sym} 3970 -6680 0 0 {name=x183}
C {adc_sar_wafflecap_dummy.sym} 3640 -6680 0 0 {name=x184}
C {adc_sar_wafflecap_dummy.sym} 3310 -6680 0 0 {name=x185}
C {adc_sar_wafflecap_dummy.sym} 2950 -6680 0 0 {name=x186}
C {adc_sar_wafflecap_dummy.sym} 2600 -6680 0 0 {name=x187}
C {adc_sar_wafflecap_dummy.sym} 2260 -6680 0 0 {name=x188}
C {adc_sar_wafflecap_dummy.sym} 1910 -6680 0 0 {name=x189}
C {adc_sar_wafflecap_dummy.sym} 1560 -6680 0 0 {name=x190}
C {adc_sar_wafflecap_dummy.sym} 1210 -6680 0 0 {name=x191}
C {adc_sar_wafflecap_dummy.sym} 880 -6680 0 0 {name=x192}
C {adc_sar_wafflecap_gate.sym} 4910 -3160 0 0 {name=x14}
C {adc_sar_wafflecap_dummy.sym} 5350 -3110 0 0 {name=x15}
C {adc_sar_wafflecap_dummy.sym} 5350 -3730 0 0 {name=x16}
C {adc_sar_wafflecap_dummy.sym} 5350 -4060 0 0 {name=x32}
C {adc_sar_wafflecap_dummy.sym} 5350 -4380 0 0 {name=x47}
C {adc_sar_wafflecap_dummy.sym} 5350 -4710 0 0 {name=x48}
C {adc_sar_wafflecap_dummy.sym} 5350 -5060 0 0 {name=x63}
C {adc_sar_wafflecap_dummy.sym} 5350 -5390 0 0 {name=x64}
C {adc_sar_wafflecap_dummy.sym} 5350 -5710 0 0 {name=x79}
C {adc_sar_wafflecap_dummy.sym} 5350 -6040 0 0 {name=x80}
C {adc_sar_wafflecap_dummy.sym} 5350 -6350 0 0 {name=x95}
C {adc_sar_wafflecap_dummy.sym} 5350 -6680 0 0 {name=x96}
C {adc_sar_wafflecap_8_8.sym} 1270 -3350 0 0 {name=x19}
C {adc_sar_wafflecap_dummy.sym} 3970 -3430 0 0 {name=x27}
C {adc_sar_wafflecap_8_8.sym} 1620 -3350 0 0 {name=x20}
C {adc_sar_wafflecap_dummy.sym} 3640 -3430 0 0 {name=x26}
C {adc_sar_wafflecap_8_2.sym} 2740 -3030 0 0 {name=x7}
C {adc_sar_wafflecap_8_4.sym} 2810 -3120 0 0 {name=x8}
C {adc_sar_wafflecap_8_1.sym} 3080 -3090 0 0 {name=x9}
C {adc_sar_wafflecap_dummy.sym} 3640 -3110 0 0 {name=x10}
C {adc_sar_noise_cell1.sym} 4220 -1060 0 0 {name=x_cap_[1..12]}
C {vdd.sym} 4370 -1300 0 0 {name=l119 lab=VDD}
C {gnd.sym} 4370 -1160 0 0 {name=l276 lab=GND}
